* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* CDL Netlist:                                              *
*                                                           *
* Cell Name  : MultiChannel_ST                              *
* Netlisted  : Thu May 13 11:45:17 2021                     *
* PVS Version: 16.15-s010 Fri Jun 28 22:24:07 PDT 2019      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
*.LDD
*.DEVTMPLT 0 MN(ne) ne ndiff(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 1 MP(pe) pe pdiff(D) p1trm(G) pdiff(S) nwtrm(B)
*.DEVTMPLT 2 MN(nel) nel ndiff(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 3 MN(nelna) nelna ndiff(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 4 MN(nesvt) nesvt ndiff(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 5 MP(pel) pel pdiff(D) p1trm(G) pdiff(S) nwtrm(B)
*.DEVTMPLT 6 MP(pesvt) pesvt pdiff(D) p1trm(G) pdiff(S) nwtrm(B)
*.DEVTMPLT 7 MN(nei) nei ndiff(D) p1trm(G) ndiff(S) pwitrm(B)
*.DEVTMPLT 8 MP(pei) pei pdiff(D) p1trm(G) pdiff(S) dnwtrm(B)
*.DEVTMPLT 9 MN(neli) neli ndiff(D) p1trm(G) ndiff(S) pwitrm(B)
*.DEVTMPLT 10 MP(peli) peli pdiff(D) p1trm(G) pdiff(S) dnwtrm(B)
*.DEVTMPLT 11 MN(nelnai) nelnai ndiff(D) p1trm(G) ndiff(S) pwitrm(B)
*.DEVTMPLT 12 MN(nesvti) nesvti ndiff(D) p1trm(G) ndiff(S) pwitrm(B)
*.DEVTMPLT 13 MP(pesvti) pesvti pdiff(D) p1trm(G) pdiff(S) dnwtrm(B)
*.DEVTMPLT 14 NEI_6() nei_6 ndiff(D) p1trm(G) ndiff(S) pwitrm(B) dnwtrm(NW) bulk(SB)
*.DEVTMPLT 15 NEI_M_6() nei_m_6 ndiff(D) p1trm(G) ndiff(S) pwitrm(B) dnwtrm(NW) bulk(SB)
*.DEVTMPLT 16 NELI_6() neli_6 ndiff(D) p1trm(G) ndiff(S) pwitrm(B) dnwtrm(NW) bulk(SB)
*.DEVTMPLT 17 NELI_M_6() neli_m_6 ndiff(D) p1trm(G) ndiff(S) pwitrm(B) dnwtrm(NW) bulk(SB)
*.DEVTMPLT 18 NELNAI_6() nelnai_6 ndiff(D) p1trm(G) ndiff(S) pwitrm(B) dnwtrm(NW) bulk(SB)
*.DEVTMPLT 19 NELNAI_M_6() nelnai_m_6 ndiff(D) p1trm(G) ndiff(S) pwitrm(B) dnwtrm(NW) bulk(SB)
*.DEVTMPLT 20 NESVTI_6() nesvti_6 ndiff(D) p1trm(G) ndiff(S) pwitrm(B) dnwtrm(NW) bulk(SB)
*.DEVTMPLT 21 NESVTI_M_6() nesvti_m_6 ndiff(D) p1trm(G) ndiff(S) pwitrm(B) dnwtrm(NW) bulk(SB)
*.DEVTMPLT 22 PE_5() pe_5 pdiff(D) p1trm(G) pdiff(S) nwtrm(B) bulk(SB)
*.DEVTMPLT 23 PEL_5() pel_5 pdiff(D) p1trm(G) pdiff(S) nwtrm(B) bulk(SB)
*.DEVTMPLT 24 PEI_5() pei_5 pdiff(D) p1trm(G) pdiff(S) dnwtrm(B) bulk(SB)
*.DEVTMPLT 25 PEI_M_5() pei_m_5 pdiff(D) p1trm(G) pdiff(S) dnwtrm(B) bulk(SB)
*.DEVTMPLT 26 PELI_5() peli_5 pdiff(D) p1trm(G) pdiff(S) dnwtrm(B) bulk(SB)
*.DEVTMPLT 27 PELI_M_5() peli_m_5 pdiff(D) p1trm(G) pdiff(S) dnwtrm(B) bulk(SB)
*.DEVTMPLT 28 PESVT_5() pesvt_5 pdiff(D) p1trm(G) pdiff(S) nwtrm(B) bulk(SB)
*.DEVTMPLT 29 PESVTI_5() pesvti_5 pdiff(D) p1trm(G) pdiff(S) dnwtrm(B) bulk(SB)
*.DEVTMPLT 30 PESVTI_M_5() pesvti_m_5 pdiff(D) p1trm(G) pdiff(S) dnwtrm(B) bulk(SB)
*.DEVTMPLT 31 MN(nmma) nmma_d hvnwtrm(D) p1trm(G) hvnwtrm(S) bulk(B)
*.DEVTMPLT 32 MN(nmma_bjt) nmma_b hvnwtrm(D) p1trm(G) hvnwtrm(S) bulk(B)
*.DEVTMPLT 33 MP(pmma) pmma_d pwitrm(D) p1trm(G) pwitrm(S) dnwtrm(B)
*.DEVTMPLT 34 PMMA_BJT() pmma_b pwitrm(D) p1trm(G) pwitrm(S) dnwtrm(B) bulk(SB)
*.DEVTMPLT 35 MN(nma) nma_d ndiff(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 36 MN(nma_bjt) nma_b ndiff(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 37 MP(pma) pma_d pdiff(D) p1trm(G) pdiff(S) hnw(B)
*.DEVTMPLT 38 PMA_BJT() pma_b pdiff(D) p1trm(G) pdiff(S) hnw(B) bulk(SB)
*.DEVTMPLT 39 MP(pmb) pmb pdiff(D) p1trm(G) pdiff(S) dnwtrm(B)
*.DEVTMPLT 40 MN(nmmc) nmmc_d ndftrm(D) p1trm(G) ndftrm(S) bulk(B)
*.DEVTMPLT 41 MN(nmmd) nmmd_d ndftrm(D) p1trm(G) ndftrm(S) bulk(B)
*.DEVTMPLT 42 MN(nhhv) nhhv_d ndftrm(D) p1trm(G) ndftrm(S) bulk(B)
*.DEVTMPLT 43 MN(nhhvd) nhhvd_d ndftrm(D) p1trm(G) ndftrm(S) bulk(B)
*.DEVTMPLT 44 MN(nmmc_bjt) nmmc_b ndftrm(D) p1trm(G) ndftrm(S) bulk(B)
*.DEVTMPLT 45 MN(nmmd_bjt) nmmd_b ndftrm(D) p1trm(G) ndftrm(S) bulk(B)
*.DEVTMPLT 46 MN(nhhv_bjt) nhhv_b ndftrm(D) p1trm(G) ndftrm(S) bulk(B)
*.DEVTMPLT 47 MN(nhhvd_bjt) nhhvd_b ndftrm(D) p1trm(G) ndftrm(S) bulk(B)
*.DEVTMPLT 48 MP(pmmc) pmmc_d pdf(D) p1trm(G) pdf(S) hnw(B)
*.DEVTMPLT 49 PMMC_BJT() pmmc_b pdf(D) p1trm(G) pdf(S) hnw(B) bulk(SB)
*.DEVTMPLT 50 MP(phhv) phhv_d pdf(D) p1trm(G) pdf(S) hnw(B)
*.DEVTMPLT 51 PHHV_BJT() phhv_b pdf(D) p1trm(G) pdf(S) hnw(B) bulk(SB)
*.DEVTMPLT 52 LDDN(nmc) nmc_d ndftrm(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 53 LDDN(nhv) nhv_d ndftrm(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 54 LDDN(nhvd) nhvd_d ndftrm(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 55 LDDN(nmc_bjt) nmc_b ndftrm(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 56 LDDN(nhv_bjt) nhv_b ndftrm(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 57 LDDN(nhvd_bjt) nhvd_b ndftrm(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 58 LDDP(pmc) pmc_d pdf(D) p1trm(G) pdiff(S) hnw(B)
*.DEVTMPLT 59 PMC_BJT() pmc_b pdf(D) p1trm(G) pdiff(S) hnw(B) bulk(SB)
*.DEVTMPLT 60 LDDP(phv) phv_d pdf(D) p1trm(G) pdiff(S) hnw(B)
*.DEVTMPLT 61 PHV_BJT() phv_b pdf(D) p1trm(G) pdiff(S) hnw(B) bulk(SB)
*.DEVTMPLT 62 LDDN(nedi) nedi2_d dnwtrm(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 63 LDDN(nedia) nedia2_d dnwtrm(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 64 LDDP(ped) ped12_d pwitrm(D) p1trm(G) pdiff(S) bulk(B)
*.DEVTMPLT 65 LDDP(ped2) ped22_d pwitrm(D) p1trm(G) pdiff(S) bulk(B)
*.DEVTMPLT 66 LDDN(nedi_bjt) nedi2_b dnwtrm(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 67 LDDN(nedia_bjt) nedia2_b dnwtrm(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 68 LDDP(ped_bjt) ped12_b pwitrm(D) p1trm(G) pdiff(S) bulk(B)
*.DEVTMPLT 69 LDDP(ped2_bjt) ped22_b pwitrm(D) p1trm(G) pdiff(S) bulk(B)
*.DEVTMPLT 70 Q(qpva) qpva bulk(C) nwtrm(B) pdiff(E)
*.DEVTMPLT 71 Q(qpvb) qpvb bulk(C) nwtrm(B) pdiff(E)
*.DEVTMPLT 72 Q(qpvc) qpvc bulk(C) nwtrm(B) pdiff(E)
*.DEVTMPLT 73 Q(qpvascr) qpvascr bulk(C) dnwtrm(B) pwitrm(E)
*.DEVTMPLT 74 Q(qpvhscr) qpvhscr bulk(C) hnw(B) pdf(E)
*.DEVTMPLT 75 Q(qpvhbscr) qpvhbscr bulk(C) hnw(B) pwitrm(E)
*.DEVTMPLT 76 Q(qnva) qnva dnwtrm(C) pwitrm(B) ndiff(E) bulk(S)
*.DEVTMPLT 77 Q(qnvb) qnvb dnwtrm(C) pwitrm(B) ndiff(E) bulk(S)
*.DEVTMPLT 78 Q(qnvba) qnvba dnwtrm(C) pwitrm(B) ndiff(E) bulk(S)
*.DEVTMPLT 79 Q(qnvc) qnvc dnwtrm(C) pwitrm(B) ndiff(E) bulk(S)
*.DEVTMPLT 80 Q(qnvca) qnvca dnwtrm(C) pwitrm(B) ndiff(E) bulk(S)
*.DEVTMPLT 81 Q(qnvz) qnvz dnwtrm(C) pwitrm(B) ndiff(E) bulk(S)
*.DEVTMPLT 82 MN(nn3) nnm ndiff(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 83 MN(ne3) nem ndiff(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 84 MN(nd3) ndm ndiff(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 85 MN(ne3lna) nemlna ndiff(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 86 MP(pe3) pem pdiff(D) p1trm(G) pdiff(S) nwtrm(B)
*.DEVTMPLT 87 MP(pe3ln) pemln pdiff(D) p1trm(G) pdiff(S) nwtrm(B)
*.DEVTMPLT 88 MP(pe3lna) pemlna pdiff(D) p1trm(G) pdiff(S) nwtrm(B)
*.DEVTMPLT 89 MN(ne3i) nemi ndiff(D) p1trm(G) ndiff(S) pwitrm(B)
*.DEVTMPLT 90 MN(nd3i) ndmi ndiff(D) p1trm(G) ndiff(S) pwitrm(B)
*.DEVTMPLT 91 MN(ne3lnai) nemlnai ndiff(D) p1trm(G) ndiff(S) pwitrm(B)
*.DEVTMPLT 92 MN(nds3i) ndsmiP ndiff(D) p1trm(G) ndiff(S) pwitrm(B)
*.DEVTMPLT 93 MN(nds3i) ndsmiE ndiff(D) p1trm(G) ndiff(S) pwitrm(B)
*.DEVTMPLT 94 MP(pe3i) pemi pdiff(D) p1trm(G) pdiff(S) dnwtrm(B)
*.DEVTMPLT 95 MP(pe3lni) pemlni pdiff(D) p1trm(G) pdiff(S) dnwtrm(B)
*.DEVTMPLT 96 MP(pe3lnai) pemlnai pdiff(D) p1trm(G) pdiff(S) dnwtrm(B)
*.DEVTMPLT 97 NE3I_6() nemi_6 ndiff(D) p1trm(G) ndiff(S) pwitrm(B) dnwtrm(NW) bulk(SB)
*.DEVTMPLT 98 NE3I_M_6() nemi_m_6 ndiff(D) p1trm(G) ndiff(S) pwitrm(B) dnwtrm(NW) bulk(SB)
*.DEVTMPLT 99 ND3I_6() ndmi_6 ndiff(D) p1trm(G) ndiff(S) pwitrm(B) dnwtrm(NW) bulk(SB)
*.DEVTMPLT 100 ND3I_M_6() ndmi_m_6 ndiff(D) p1trm(G) ndiff(S) pwitrm(B) dnwtrm(NW) bulk(SB)
*.DEVTMPLT 101 NE3LNAI_6() nemlnai_6 ndiff(D) p1trm(G) ndiff(S) pwitrm(B) dnwtrm(NW) bulk(SB)
*.DEVTMPLT 102 NE3LNAI_M_6() nemlnai_m_6 ndiff(D) p1trm(G) ndiff(S) pwitrm(B) dnwtrm(NW) bulk(SB)
*.DEVTMPLT 103 PE3_5() pem_5 pdiff(D) p1trm(G) pdiff(S) nwtrm(B) bulk(SB)
*.DEVTMPLT 104 PE3LN_5() pemln_5 pdiff(D) p1trm(G) pdiff(S) nwtrm(B) bulk(SB)
*.DEVTMPLT 105 PE3I_5() pemi_5 pdiff(D) p1trm(G) pdiff(S) dnwtrm(B) bulk(SB)
*.DEVTMPLT 106 PE3I_M_5() pemi_m_5 pdiff(D) p1trm(G) pdiff(S) dnwtrm(B) bulk(SB)
*.DEVTMPLT 107 PE3LNI_5() pemlni_5 pdiff(D) p1trm(G) pdiff(S) dnwtrm(B) bulk(SB)
*.DEVTMPLT 108 PE3LNI_M_5() pemlni_m_5 pdiff(D) p1trm(G) pdiff(S) dnwtrm(B) bulk(SB)
*.DEVTMPLT 109 PE3LNA_5() pemlna_5 pdiff(D) p1trm(G) pdiff(S) nwtrm(B) bulk(SB)
*.DEVTMPLT 110 PE3LNAI_5() pemlnai_5 pdiff(D) p1trm(G) pdiff(S) dnwtrm(B) bulk(SB)
*.DEVTMPLT 111 PE3LNAI_M_5() pemlnai_m_5 pdiff(D) p1trm(G) pdiff(S) dnwtrm(B) bulk(SB)
*.DEVTMPLT 112 MOSVC() mosvc p1trm(G) nwtrm(NW) bulk(SB)
*.DEVTMPLT 113 MOSVCI() mosvci p1trm(G) pwitrm(PW) dnwtrm(DNW) bulk(SB)
*.DEVTMPLT 114 MOSVCI_M() mosvci_m p1trm(G) pwitrm(PW) dnwtrm(DNW) bulk(SB)
*.DEVTMPLT 115 MOSVC3() mosvcm p1trm(G) nwtrm(NW) bulk(SB)
*.DEVTMPLT 116 MOSVC3I() mosvcim p1trm(G) pwitrm(PW) dnwtrm(DNW) bulk(SB)
*.DEVTMPLT 117 MOSVC3I_M() mosvcim_m p1trm(G) pwitrm(PW) dnwtrm(DNW) bulk(SB)
*.DEVTMPLT 118 Q(qpva3) qpvma bulk(C) nwtrm(B) pdiff(E)
*.DEVTMPLT 119 Q(qpvb3) qpvmb bulk(C) nwtrm(B) pdiff(E)
*.DEVTMPLT 120 Q(qpvc3) qpvmc bulk(C) nwtrm(B) pdiff(E)
*.DEVTMPLT 121 R(rnw) rnw nwtrm(POS) nwtrm(NEG) bulk(SUB)
*.DEVTMPLT 122 R(rnw_scr) rnw_scr nwtrm(POS) nwtrm(NEG) bulk(SUB)
*.DEVTMPLT 123 R(rdnwmv) rdnwmv dnwtrm(POS) dnwtrm(NEG) bulk(SUB)
*.DEVTMPLT 124 R(rdn) rdn ndiff(POS) ndiff(NEG) bulk(SUB)
*.DEVTMPLT 125 R(rdn) rdn_g ndiff(POS) ndiff(NEG) bulk(SUB)
*.DEVTMPLT 126 R(rdn) rdni ndiff(POS) ndiff(NEG) pwitrm(SUB)
*.DEVTMPLT 127 R(rdn) rdn_gi ndiff(POS) ndiff(NEG) pwitrm(SUB)
*.DEVTMPLT 128 R(rdn_esd) rdn_esdg ndiff(POS) ndiff(NEG) bulk(SUB)
*.DEVTMPLT 129 R(rdp) rdp pdiff(POS) pdiff(NEG) nwtrm(SUB)
*.DEVTMPLT 130 R(rdp) rdp_g pdiff(POS) pdiff(NEG) nwtrm(SUB)
*.DEVTMPLT 131 R(rdp) rdpi pdiff(POS) pdiff(NEG) dnwtrm(SUB)
*.DEVTMPLT 132 R(rdp) rdp_gi pdiff(POS) pdiff(NEG) dnwtrm(SUB)
*.DEVTMPLT 133 R(rdp_io) rdp_io_g pdiff(POS) pdiff(NEG) dnwtrm(SUB)
*.DEVTMPLT 134 R(rdp_esd) rdp_esdg pdiff(POS) pdiff(NEG) hnw(SUB)
*.DEVTMPLT 135 tag_60v() tdf_60 df_vlbl(N1)
*.DEVTMPLT 136 tag_25v() tdf_25 df_vlbl(N1)
*.DEVTMPLT 137 R(s_res) s_res bulk(POS) bulk(NEG)
*.DEVTMPLT 138 D(dn) d_dn bulk(POS) ndiff(NEG)
*.DEVTMPLT 139 D(dn) d_dni1 pwitrm(POS) ndiff(NEG)
*.DEVTMPLT 140 D(dn) d_dni2 pdf(POS) ndiff(NEG)
*.DEVTMPLT 141 D(p_dn) p_dn bulk(POS) ndiff(NEG)
*.DEVTMPLT 142 D(p_dn) p_dni1 pwitrm(POS) ndiff(NEG)
*.DEVTMPLT 143 D(p_dn) p_dni2 pdf(POS) ndiff(NEG)
*.DEVTMPLT 144 D(p_dn) p_dndpl bulk(POS) ndiff(NEG)
*.DEVTMPLT 145 D(p_dn) p_dndpli pwitrm(POS) ndiff(NEG)
*.DEVTMPLT 146 D(p_dbn) p_dbn bulk(POS) bndiff(NEG)
*.DEVTMPLT 147 D(dp) d_dp pdiff(POS) nwtrm(NEG)
*.DEVTMPLT 148 D(dp) d_dpi1 pdiff(POS) dnwtrm(NEG)
*.DEVTMPLT 149 D(dp) d_dpi2 pdiff(POS) hnw(NEG)
*.DEVTMPLT 150 D(p_dp) p_dp pdiff(POS) nwtrm(NEG)
*.DEVTMPLT 151 D(p_dp) p_dpi1 pdiff(POS) dnwtrm(NEG)
*.DEVTMPLT 152 D(p_dp) p_dpi2 pdiff(POS) hnw(NEG)
*.DEVTMPLT 153 D(p_dpndf) p_dpndf pdiff(POS) ndftrm(NEG)
*.DEVTMPLT 154 D(p_dpndf) pdpndfh pdiff(POS) hnw(NEG)
*.DEVTMPLT 155 D(dnw) d_dnw bulk(POS) nwtrm(NEG)
*.DEVTMPLT 156 D(p_dnw) p_dnw bulk(POS) nwtrm(NEG)
*.DEVTMPLT 157 D(dhnw) d_dhnw bulk(POS) hvnwtrm(NEG)
*.DEVTMPLT 158 D(p_dhnw) p_dhnw bulk(POS) hvnwtrm(NEG)
*.DEVTMPLT 159 D(dhpw) d_dhpw pwitrm(POS) dnwtrm(NEG)
*.DEVTMPLT 160 D(p_dhpw) p_dhpw pwitrm(POS) dnwtrm(NEG)
*.DEVTMPLT 161 D(ddnw) d_ddnw bulk(POS) dnwtrm(NEG)
*.DEVTMPLT 162 D(p_ddnw) p_ddnw bulk(POS) dnwtrm(NEG)
*.DEVTMPLT 163 D(ddnwmv) d_ddnwmv bulk(POS) dnwtrm(NEG)
*.DEVTMPLT 164 D(p_ddnwmv) p_ddnwmv bulk(POS) dnwtrm(NEG)
*.DEVTMPLT 165 D(dphoa) dphoa bulk(POS) dnwtrm(NEG) dphopin3(SUB)
*.DEVTMPLT 166 D(dphob) dphob bulk(POS) dnwtrm(NEG) dphopin3(SUB)
*.DEVTMPLT 167 DPHOC() dphoc bulk(A) catdiff(C) p1trm(POLY1) nwtrm(NW) dphopin3(LPOWER)
*.DEVTMPLT 168 DPHOCFP() dphocfp bulk(A) catdiff(C) p1trm(POLY1) nwtrm(NW) dphopin3(LPOWER)
*.DEVTMPLT 169 DPHOC0() dphoc0 bulk(A) catdiff(C) p1trm(POLY1) nwtrm(NW) dphopin3(LPOWER)
*.DEVTMPLT 170 DPHOD() dphod anodiff(A1) bulk(A2) dphod_c(C) p1trm(POLY1) dphod_nw(NW) dphopin3(LPOWER)
*.DEVTMPLT 171 DPHODFP() dphodfp anodiff(A1) bulk(A2) dphod_c(C) p1trm(POLY1) dphod_nw(NW) dphopin3(LPOWER)
*.DEVTMPLT 172 DPHOD0() dphod0 anodiff(A1) bulk(A2) dphod_c(C) p1trm(POLY1) dphod_nw(NW) dphopin3(LPOWER)
*.DEVTMPLT 173 D(dapda) dapda bulk(POS) catdiff(NEG) dphopin3(SUB)
*.DEVTMPLT 174 D(dapda0) dapda0 bulk(POS) catdiff(NEG) dphopin3(SUB)
*.DEVTMPLT 175 D(dspada) dspada bulk(POS) catdiff(NEG) dphopin3(SUB)
*.DEVTMPLT 176 D(dspada0) dspada0 bulk(POS) catdiff(NEG) dphopin3(SUB)
*.DEVTMPLT 177 DAPB() dapb bulk(A) catdiff(C) davl_c2(C2) dphopin3(LPOWER)
*.DEVTMPLT 178 DAPB0() dapb0 bulk(A) catdiff(C) davl_c2(C2) dphopin3(LPOWER)
*.DEVTMPLT 179 DSPB() dspb bulk(A) catdiff(C) davl_c2(C2) dphopin3(PHOTON)
*.DEVTMPLT 180 DSPB0() dspb0 bulk(A) catdiff(C) davl_c2(C2) dphopin3(PHOTON)
*.DEVTMPLT 181 D(dipdnw) d_dipw pwitrm(POS) dnwtrm(NEG)
*.DEVTMPLT 182 D(p_dipdnw) p_dipw pwitrm(POS) dnwtrm(NEG)
*.DEVTMPLT 183 D(dipdnwmv) d_dipwmv pwitrm(POS) dnwtrm(NEG)
*.DEVTMPLT 184 D(p_dipdnwmv) p_dipwmv pwitrm(POS) dnwtrm(NEG)
*.DEVTMPLT 185 D(p_ddpldnw) pddpldnw pwitrm(POS) dnwtrm(NEG)
*.DEVTMPLT 186 D(dndf) d_dndf bulk(POS) ndftrm(NEG)
*.DEVTMPLT 187 D(p_dndf) p_dndf bulk(POS) ndftrm(NEG)
*.DEVTMPLT 188 D(dpdwhn) d_dpdwhn pdf(POS) hnw(NEG)
*.DEVTMPLT 189 D(p_dpdwhn) p_dpdwhn pdf(POS) hnw(NEG)
*.DEVTMPLT 190 D(dwhn) d_dwhn bulk(POS) hnw(NEG)
*.DEVTMPLT 191 D(p_dwhn) p_dwhn bulk(POS) hnw(NEG)
*.DEVTMPLT 192 D(dpdd_scr) dpdd_scr pwitrm(POS) dnwtrm(NEG)
*.DEVTMPLT 193 D(p_dpdddnw) pdpdddnw pwitrm(POS) dnwtrm(NEG)
*.DEVTMPLT 194 D(dnpdd_scr) dnpddscr pwitrm(POS) ndiff(NEG)
*.DEVTMPLT 195 D(dpp20) dpp20 pwitrm(POS) dnwtrm(NEG)
*.DEVTMPLT 196 D(dnp20) dnp20 bulk(POS) ndftrm(NEG)
*.DEVTMPLT 197 D(dpol) dpol dpol_p(POS) dpol_n(NEG)
*.DEVTMPLT 198 D(dnhpw) d_dnhpw bulk(POS) ndiff(NEG)
*.DEVTMPLT 199 D(dnhpw) d_dnhpwi pwitrm(POS) ndiff(NEG)
*.DEVTMPLT 200 D(p_dnhpw) p_dnhpw bulk(POS) ndiff(NEG)
*.DEVTMPLT 201 D(p_dnhpw) p_dnhpwi pwitrm(POS) ndiff(NEG)
*.DEVTMPLT 202 D(dphnw) d_dphnw pdiff(POS) hvnwtrm(NEG)
*.DEVTMPLT 203 D(dphnw) d_dphnw1 pdiff(POS) dnwtrm(NEG)
*.DEVTMPLT 204 D(dphnw) d_dphnw2 pdiff(POS) hnw(NEG)
*.DEVTMPLT 205 D(p_dphnw) p_dphnw pdiff(POS) hvnwtrm(NEG)
*.DEVTMPLT 206 D(p_dphnw) p_dphnw1 pdiff(POS) dnwtrm(NEG)
*.DEVTMPLT 207 D(p_dphnw) p_dphnw2 pdiff(POS) hnw(NEG)
*.DEVTMPLT 208 D(dpdnwmv) ddpdnwmv pdiff(POS) dnwtrm(NEG)
*.DEVTMPLT 209 D(p_dpdnwmv) pdpdnwmv pdiff(POS) dnwtrm(NEG)
*.DEVTMPLT 210 D(dpdnw) d_dpdnw pdiff(POS) dnwtrm(NEG)
*.DEVTMPLT 211 D(p_dpdnw) p_dpdnw pdiff(POS) dnwtrm(NEG)
*.DEVTMPLT 212 D(dpwhn) d_dpwhn pdiff(POS) hnw(NEG)
*.DEVTMPLT 213 D(p_dpwhn) p_dpwhn pdiff(POS) hnw(NEG)
*.DEVTMPLT 214 D(dsb) d_dsb d_dsdf(POS) hnw(NEG) bulk(SUB)
*.DEVTMPLT 215 D(dsba) d_dsba d_dsdf(POS) hnw(NEG) bulk(SUB)
*.DEVTMPLT 216 R(rnw3) rnwm nwtrm(POS) nwtrm(NEG) bulk(SUB)
*.DEVTMPLT 217 R(rnw3_scr) rnwm_scr nwtrm(POS) nwtrm(NEG) bulk(SUB)
*.DEVTMPLT 218 R(rdn3) rdnm ndiff(POS) ndiff(NEG) bulk(SUB)
*.DEVTMPLT 219 R(rdn3) rdnm_g ndiff(POS) ndiff(NEG) bulk(SUB)
*.DEVTMPLT 220 R(rdn3) rdnmi ndiff(POS) ndiff(NEG) pwitrm(SUB)
*.DEVTMPLT 221 R(rdn3) rdnm_gi ndiff(POS) ndiff(NEG) pwitrm(SUB)
*.DEVTMPLT 222 R(rdp3) rdpm pdiff(POS) pdiff(NEG) nwtrm(SUB)
*.DEVTMPLT 223 R(rdp3) rdpm_g pdiff(POS) pdiff(NEG) nwtrm(SUB)
*.DEVTMPLT 224 R(rdp3) rdpmi pdiff(POS) pdiff(NEG) dnwtrm(SUB)
*.DEVTMPLT 225 R(rdp3) rdpm_gi pdiff(POS) pdiff(NEG) dnwtrm(SUB)
*.DEVTMPLT 226 D(dn3) d_dnm bulk(POS) ndiff(NEG)
*.DEVTMPLT 227 D(dn3) d_dnmi1 pwitrm(POS) ndiff(NEG)
*.DEVTMPLT 228 D(dn3) d_dnmi2 pdf(POS) ndiff(NEG)
*.DEVTMPLT 229 D(p_dn3) p_dnm bulk(POS) ndiff(NEG)
*.DEVTMPLT 230 D(p_dn3) p_dnmi1 pwitrm(POS) ndiff(NEG)
*.DEVTMPLT 231 D(p_dn3) p_dnmi2 pdf(POS) ndiff(NEG)
*.DEVTMPLT 232 D(dnn3) d_dnnm bulk(POS) ndiff(NEG)
*.DEVTMPLT 233 D(p_dnn3) p_dnnm bulk(POS) ndiff(NEG)
*.DEVTMPLT 234 D(p_dn3dpl) pdnmdpl bulk(POS) ndiff(NEG)
*.DEVTMPLT 235 D(p_dn3dpl) pdnmdpli pwitrm(POS) ndiff(NEG)
*.DEVTMPLT 236 D(dp3) d_dpm pdiff(POS) nwtrm(NEG)
*.DEVTMPLT 237 D(dp3) d_dpmi1 pdiff(POS) dnwtrm(NEG)
*.DEVTMPLT 238 D(dp3) d_dpmi2 pdiff(POS) hnw(NEG)
*.DEVTMPLT 239 D(p_dp3) p_dpm pdiff(POS) nwtrm(NEG)
*.DEVTMPLT 240 D(p_dp3) p_dpmi1 pdiff(POS) dnwtrm(NEG)
*.DEVTMPLT 241 D(p_dp3) p_dpmi2 pdiff(POS) hnw(NEG)
*.DEVTMPLT 242 D(dnw3) d_dnwm bulk(POS) nwtrm(NEG)
*.DEVTMPLT 243 D(p_dnw3) p_dnwm bulk(POS) nwtrm(NEG)
*.DEVTMPLT 244 R(rpp1k1) rpp1k1_2 p1trm(POS) p1trm(NEG)
*.DEVTMPLT 245 R(rpp1k1_3) rpp1k1_s p1trm(POS) p1trm(NEG) bulk(SUB)
*.DEVTMPLT 246 R(rpp1k1_3) rpp1k1_p p1trm(POS) p1trm(NEG) pwitrm(SUB)
*.DEVTMPLT 247 R(rpp1k1_3) rpp1k1fp p1trm(POS) p1trm(NEG) pdf(SUB)
*.DEVTMPLT 248 R(rpp1k1_3) rpp1k1_n p1trm(POS) p1trm(NEG) nwtrm(SUB)
*.DEVTMPLT 249 R(rpp1k1_3) rpp1k1_d p1trm(POS) p1trm(NEG) dnwtrm(SUB)
*.DEVTMPLT 250 R(rpp1k1_3) rpp1k1_h p1trm(POS) p1trm(NEG) hvnwtrm(SUB)
*.DEVTMPLT 251 R(rpp1k1_3) rpp1k1hn p1trm(POS) p1trm(NEG) hnw(SUB)
*.DEVTMPLT 252 R(rpp1k1_3) rpp1k1fn p1trm(POS) p1trm(NEG) ndftrm(SUB)
*.DEVTMPLT 253 R(rnp1) rnp1_2 p1trm(POS) p1trm(NEG)
*.DEVTMPLT 254 R(rnp1_3) rnp1_s p1trm(POS) p1trm(NEG) bulk(SUB)
*.DEVTMPLT 255 R(rnp1_3) rnp1_p p1trm(POS) p1trm(NEG) pwitrm(SUB)
*.DEVTMPLT 256 R(rnp1_3) rnp1fp p1trm(POS) p1trm(NEG) pdf(SUB)
*.DEVTMPLT 257 R(rnp1_3) rnp1_n p1trm(POS) p1trm(NEG) nwtrm(SUB)
*.DEVTMPLT 258 R(rnp1_3) rnp1_d p1trm(POS) p1trm(NEG) dnwtrm(SUB)
*.DEVTMPLT 259 R(rnp1_3) rnp1_h p1trm(POS) p1trm(NEG) hvnwtrm(SUB)
*.DEVTMPLT 260 R(rnp1_3) rnp1hn p1trm(POS) p1trm(NEG) hnw(SUB)
*.DEVTMPLT 261 R(rnp1_3) rnp1fn p1trm(POS) p1trm(NEG) ndftrm(SUB)
*.DEVTMPLT 262 R(rpp1) rpp1_2 p1trm(POS) p1trm(NEG)
*.DEVTMPLT 263 R(rpp1_3) rpp1_s p1trm(POS) p1trm(NEG) bulk(SUB)
*.DEVTMPLT 264 R(rpp1_3) rpp1_p p1trm(POS) p1trm(NEG) pwitrm(SUB)
*.DEVTMPLT 265 R(rpp1_3) rpp1fp p1trm(POS) p1trm(NEG) pdf(SUB)
*.DEVTMPLT 266 R(rpp1_3) rpp1_n p1trm(POS) p1trm(NEG) nwtrm(SUB)
*.DEVTMPLT 267 R(rpp1_3) rpp1_d p1trm(POS) p1trm(NEG) dnwtrm(SUB)
*.DEVTMPLT 268 R(rpp1_3) rpp1_h p1trm(POS) p1trm(NEG) hvnwtrm(SUB)
*.DEVTMPLT 269 R(rpp1_3) rpp1hn p1trm(POS) p1trm(NEG) hnw(SUB)
*.DEVTMPLT 270 R(rpp1_3) rpp1fn p1trm(POS) p1trm(NEG) ndftrm(SUB)
*.DEVTMPLT 271 R(rpp1s) rpp1s_2 p1trm(POS) p1trm(NEG)
*.DEVTMPLT 272 R(rpp1s_3) rpp1s_s p1trm(POS) p1trm(NEG) bulk(SUB)
*.DEVTMPLT 273 R(rpp1s_3) rpp1s_p p1trm(POS) p1trm(NEG) pwitrm(SUB)
*.DEVTMPLT 274 R(rpp1s_3) rpp1sfp p1trm(POS) p1trm(NEG) pdf(SUB)
*.DEVTMPLT 275 R(rpp1s_3) rpp1s_n p1trm(POS) p1trm(NEG) nwtrm(SUB)
*.DEVTMPLT 276 R(rpp1s_3) rpp1s_d p1trm(POS) p1trm(NEG) dnwtrm(SUB)
*.DEVTMPLT 277 R(rpp1s_3) rpp1s_h p1trm(POS) p1trm(NEG) hvnwtrm(SUB)
*.DEVTMPLT 278 R(rpp1s_3) rpp1shn p1trm(POS) p1trm(NEG) hnw(SUB)
*.DEVTMPLT 279 R(rpp1s_3) rpp1sfn p1trm(POS) p1trm(NEG) ndftrm(SUB)
*.DEVTMPLT 280 R(rnp1h) rnp1h_2 p1trm(POS) p1trm(NEG)
*.DEVTMPLT 281 R(rnp1h_3) rnp1h_s p1trm(POS) p1trm(NEG) bulk(SUB)
*.DEVTMPLT 282 R(rnp1h_3) rnp1h_p p1trm(POS) p1trm(NEG) pwitrm(SUB)
*.DEVTMPLT 283 R(rnp1h_3) rnp1hfp p1trm(POS) p1trm(NEG) pdf(SUB)
*.DEVTMPLT 284 R(rnp1h_3) rnp1h_n p1trm(POS) p1trm(NEG) nwtrm(SUB)
*.DEVTMPLT 285 R(rnp1h_3) rnp1h_d p1trm(POS) p1trm(NEG) dnwtrm(SUB)
*.DEVTMPLT 286 R(rnp1h_3) rnp1h_h p1trm(POS) p1trm(NEG) hvnwtrm(SUB)
*.DEVTMPLT 287 R(rnp1h_3) rnp1hhn p1trm(POS) p1trm(NEG) hnw(SUB)
*.DEVTMPLT 288 R(rnp1h_3) rnp1hfn p1trm(POS) p1trm(NEG) ndftrm(SUB)
*.DEVTMPLT 289 R(pfuse) pfuse p1trm(POS) p1trm(NEG)
*.DEVTMPLT 290 tag_60v() tp1_60 p1_vlbl(N1)
*.DEVTMPLT 291 tag_25v() tp1_25 p1_vlbl(N1)
*.DEVTMPLT 292 R(rm1) rm1 m1trm(POS) m1trm(NEG)
*.DEVTMPLT 293 R(rm2) rm2 m2trm(POS) m2trm(NEG)
*.DEVTMPLT 294 tag_60v() tm1_60 m1_vlbl(N1)
*.DEVTMPLT 295 tag_25v() tm1_25 m1_vlbl(N1)
*.DEVTMPLT 296 tag_60v() tm2_60 m2_vlbl(N1)
*.DEVTMPLT 297 tag_25v() tm2_25 m2_vlbl(N1)
*.DEVTMPLT 298 R(rm3) rm3 m3trm(POS) m3trm(NEG)
*.DEVTMPLT 299 tag_60v() tm3_60 m3_vlbl(N1)
*.DEVTMPLT 300 tag_25v() tm3_25 m3_vlbl(N1)
*.DEVTMPLT 301 R(rm4) rm4 m4trm(POS) m4trm(NEG)
*.DEVTMPLT 302 tag_60v() tm4_60 m4_vlbl(N1)
*.DEVTMPLT 303 tag_25v() tm4_25 m4_vlbl(N1)
*.DEVTMPLT 304 R(rmtp) rmtp mttrm(POS) mttrm(NEG)
*.DEVTMPLT 305 tag_60v() tmt_60 mt_vlbl(N1)
*.DEVTMPLT 306 tag_25v() tmt_25 mt_vlbl(N1)
*.DEVTMPLT 307 R(rmtpl) rmtpl mltrm(POS) mltrm(NEG)
*.DEVTMPLT 308 tag_60v() tml_60 ml_vlbl(N1)
*.DEVTMPLT 309 tag_25v() tml_25 ml_vlbl(N1)
*.DEVTMPLT 310 C(csf2p) d_csf2p m1atrm(POS) m1btrm(NEG)
*.DEVTMPLT 311 C(csf3) d_csf3 m1atrm(POS) m1btrm(NEG)
*.DEVTMPLT 312 C(csf3p) d_csf3p m1atrm(POS) m1btrm(NEG)
*.DEVTMPLT 313 C(csf3a) d_csf3a m1atrm(POS) m1btrm(NEG)
*.DEVTMPLT 314 C(csf4) d_csf4 m1atrm(POS) m1btrm(NEG)
*.DEVTMPLT 315 C(csf4a) d_csf4a m1atrm(POS) m1btrm(NEG)
*.DEVTMPLT 316 C(csft5) d_csft5 m1atrm(POS) m1btrm(NEG)
*.DEVTMPLT 317 C(csft5a) d_csft5a m1atrm(POS) m1btrm(NEG)
*.DEVTMPLT 318 C(csandwt3) d_cswt3 m1trm(POS) p1trm(NEG)
*.DEVTMPLT 319 C(csandwt4) d_cswt4 m1trm(POS) p1trm(NEG)
*.DEVTMPLT 320 C(cdmm4) cdmm capm2_b(POS) m2trm(NEG)
*.DEVTMPLT 321 C(cdmmh4) cdmmh capmh2_b(POS) m2trm(NEG)
*.DEVTMPLT 322 C(cmm5t) cmim capm(POS) m4trm(NEG)
*.DEVTMPLT 323 C(cmmh5t) cmimh capmh(POS) m4trm(NEG)
*.DEVTMPLT 324 C(ctmm5t) ctmm capm3_b(POS) m2trm(NEG)
*.DEVTMPLT 325 C(ctmmh5t) ctmmh capmh3_b(POS) m2trm(NEG)
*.DEVTMPLT 326 C(cmm3) cmim23f capm23f(POS) m2trm(NEG)
*.DEVTMPLT 327 C(cmmh3) cmimh23f capmh23f(POS) m2trm(NEG)
*.DEVTMPLT 328 C(cmm4) cmim34f capm34f(POS) m3trm(NEG)
*.DEVTMPLT 329 C(cmmh4) cmimh34f capmh34f(POS) m3trm(NEG)
*.DEVTMPLT 330 C(cpod) cpod p1trm(POS) bndiff(NEG) bulk(SUB)
*.DEVTMPLT 331 C(cpodhv) cpodhv p1trm(POS) bndiff(NEG) bulk(SUB)

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_1                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_1 1 2
** N=2 EP=2 FDC=0
.ends VIA3_C_CDNS_1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIATP_C_CDNS_2                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIATP_C_CDNS_2 1 2
** N=2 EP=2 FDC=0
.ends VIATP_C_CDNS_2

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIATP_C_CDNS_3                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIATP_C_CDNS_3 1 2
** N=2 EP=2 FDC=0
.ends VIATP_C_CDNS_3

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_4                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_4 1 2
** N=2 EP=2 FDC=0
.ends VIA3_C_CDNS_4

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIATP_C_CDNS_5                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIATP_C_CDNS_5 1 2
** N=2 EP=2 FDC=0
.ends VIATP_C_CDNS_5

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_6                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_6 1 2
** N=2 EP=2 FDC=0
.ends VIA3_C_CDNS_6

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIATP_C_CDNS_7                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIATP_C_CDNS_7 1 2
** N=2 EP=2 FDC=0
.ends VIATP_C_CDNS_7

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_8                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_8 1 2
** N=2 EP=2 FDC=0
.ends VIA3_C_CDNS_8

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_9                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_9 1 2
** N=2 EP=2 FDC=0
.ends VIA1_C_CDNS_9

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_10                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_10 1 2
** N=2 EP=2 FDC=0
.ends VIA1_C_CDNS_10

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_11                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_11 1 2
** N=2 EP=2 FDC=0
.ends VIA1_C_CDNS_11

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_12                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_12 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_12

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_15                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_15 1 2
** N=2 EP=2 FDC=0
.ends VIA1_C_CDNS_15

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_17                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_17 1 2
** N=2 EP=2 FDC=0
.ends VIA1_C_CDNS_17

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_18                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_18 1 2
** N=2 EP=2 FDC=0
.ends VIA1_C_CDNS_18

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_19                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_19 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_19

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_22                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_22 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_22

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_23                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_23 1 2
** N=2 EP=2 FDC=0
.ends VIA1_C_CDNS_23

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_26                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_26 1 2
** N=2 EP=2 FDC=0
.ends VIA1_C_CDNS_26

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_27                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_27 1 2
** N=2 EP=2 FDC=0
.ends VIA1_C_CDNS_27

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_28                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_28 1 2
** N=2 EP=2 FDC=0
.ends VIA1_C_CDNS_28

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_30                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_30 1 2
** N=2 EP=2 FDC=0
.ends VIA1_C_CDNS_30

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_32                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_32 1 2
** N=2 EP=2 FDC=0
.ends VIA1_C_CDNS_32

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_33                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_33 1 2
** N=2 EP=2 FDC=0
.ends VIA1_C_CDNS_33

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_34                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_34 1 2
** N=2 EP=2 FDC=0
.ends VIA1_C_CDNS_34

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_36                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_36 1 2
** N=2 EP=2 FDC=0
.ends VIA1_C_CDNS_36

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_38                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_38 1 2
** N=2 EP=2 FDC=0
.ends VIA1_C_CDNS_38

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_40                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_40 1 2
** N=2 EP=2 FDC=0
.ends VIA2_C_CDNS_40

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_171                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_171 1
** N=1 EP=1 FDC=0
.ends VIA3_C_CDNS_171

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIATP_C_CDNS_172                                *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIATP_C_CDNS_172 1
** N=1 EP=1 FDC=0
.ends VIATP_C_CDNS_172

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: M3_MTPcell                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt M3_MTPcell 1 2
** N=2 EP=2 FDC=0
X0 1 VIA3_C_CDNS_171 $T=755 3780 0 0 $X=525 $Y=430
X1 1 VIA3_C_CDNS_171 $T=2280 3780 0 0 $X=2050 $Y=430
X2 1 VIA3_C_CDNS_171 $T=3780 3780 0 0 $X=3550 $Y=430
X3 1 VIA3_C_CDNS_171 $T=5280 3780 0 0 $X=5050 $Y=430
X4 1 VIA3_C_CDNS_171 $T=6805 3780 0 0 $X=6575 $Y=430
X5 1 VIATP_C_CDNS_172 $T=755 3780 0 0 $X=375 $Y=205
X6 1 VIATP_C_CDNS_172 $T=2315 3780 0 0 $X=1935 $Y=205
X7 1 VIATP_C_CDNS_172 $T=3790 3780 0 0 $X=3410 $Y=205
X8 1 VIATP_C_CDNS_172 $T=5285 3780 0 0 $X=4905 $Y=205
X9 1 VIATP_C_CDNS_172 $T=6805 3780 0 0 $X=6425 $Y=205
.ends M3_MTPcell

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_42                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_42 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_42

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_43                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_43 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_43

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_44                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_44 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_44

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_45                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_45 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_45

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_46                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_46 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_46

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_47                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_47 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_47

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_48                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_48 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_48

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_49                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_49 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_49

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_56                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_56 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_56

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_57                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_57 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_57

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_58                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_58 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_58

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_59                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_59 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_59

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_60                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_60 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_60

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_61                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_61 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_61

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_62                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_62 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_62

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_63                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_63 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_63

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_64                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_64 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_64

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_65                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_65 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_65

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_66                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_66 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_66

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_67                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_67 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_67

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ne3_CDNS_68                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ne3_CDNS_68 1 2 3 4
** N=4 EP=4 FDC=1
M0 3 2 1 4 ne3 L=2e-06 W=8e-06 AD=3.84e-12 AS=3.84e-12 PD=1.696e-05 PS=1.696e-05 $X=0 $Y=0 $dt=83
.ends ne3_CDNS_68

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: rpp1k1_CDNS_69                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt rpp1k1_CDNS_69 1 2 3
** N=3 EP=3 FDC=1
R0 1 2 L=2.0095e-05 W=2e-06 $[rpp1k1] $X=0 $Y=0 $dt=244
.ends rpp1k1_CDNS_69

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: Ext_Iref_ST                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt Ext_Iref_ST 1 2 3
** N=6 EP=3 FDC=25
X0 1 VIA1_C_CDNS_56 $T=7800 52280 0 0 $X=7400 $Y=52090
X1 1 VIA1_C_CDNS_56 $T=9070 52280 0 0 $X=8670 $Y=52090
X2 1 VIA1_C_CDNS_56 $T=10340 52280 0 0 $X=9940 $Y=52090
X3 4 VIA1_C_CDNS_56 $T=11400 18190 0 0 $X=11000 $Y=18000
X4 1 VIA1_C_CDNS_56 $T=11400 52280 0 0 $X=11000 $Y=52090
X5 5 VIA1_C_CDNS_56 $T=12670 19750 0 0 $X=12270 $Y=19560
X6 6 VIA1_C_CDNS_56 $T=12670 53060 0 0 $X=12270 $Y=52870
X7 3 VIA1_C_CDNS_56 $T=13940 17410 0 0 $X=13540 $Y=17220
X8 4 VIA1_C_CDNS_56 $T=13940 51500 0 0 $X=13540 $Y=51310
X9 6 VIA1_C_CDNS_56 $T=15000 18970 0 0 $X=14600 $Y=18780
X10 1 VIA1_C_CDNS_56 $T=15000 52280 0 0 $X=14600 $Y=52090
X11 5 VIA1_C_CDNS_56 $T=16270 19750 0 0 $X=15870 $Y=19560
X12 6 VIA1_C_CDNS_56 $T=16270 53060 0 0 $X=15870 $Y=52870
X13 5 VIA1_C_CDNS_56 $T=17540 19750 0 0 $X=17140 $Y=19560
X14 6 VIA1_C_CDNS_56 $T=17540 53060 0 0 $X=17140 $Y=52870
X15 4 VIA1_C_CDNS_56 $T=18600 18190 0 0 $X=18200 $Y=18000
X16 1 VIA1_C_CDNS_56 $T=18600 52280 0 0 $X=18200 $Y=52090
X17 5 VIA1_C_CDNS_56 $T=19870 19750 0 0 $X=19470 $Y=19560
X18 6 VIA1_C_CDNS_56 $T=19870 53060 0 0 $X=19470 $Y=52870
X19 3 VIA1_C_CDNS_56 $T=21140 17410 0 0 $X=20740 $Y=17220
X20 4 VIA1_C_CDNS_56 $T=21140 51500 0 0 $X=20740 $Y=51310
X21 5 VIA1_C_CDNS_56 $T=22200 19750 0 0 $X=21800 $Y=19560
X22 6 VIA1_C_CDNS_56 $T=22200 53060 0 0 $X=21800 $Y=52870
X23 5 VIA1_C_CDNS_56 $T=23470 19750 0 0 $X=23070 $Y=19560
X24 6 VIA1_C_CDNS_56 $T=23470 53060 0 0 $X=23070 $Y=52870
X25 6 VIA1_C_CDNS_56 $T=24740 18970 0 0 $X=24340 $Y=18780
X26 1 VIA1_C_CDNS_56 $T=24740 52280 0 0 $X=24340 $Y=52090
X27 3 VIA1_C_CDNS_56 $T=25800 17410 0 0 $X=25400 $Y=17220
X28 4 VIA1_C_CDNS_56 $T=25800 51500 0 0 $X=25400 $Y=51310
X29 5 VIA1_C_CDNS_56 $T=27070 19750 0 0 $X=26670 $Y=19560
X30 6 VIA1_C_CDNS_56 $T=27070 53060 0 0 $X=26670 $Y=52870
X31 4 VIA1_C_CDNS_56 $T=28340 18190 0 0 $X=27940 $Y=18000
X32 1 VIA1_C_CDNS_56 $T=28340 52280 0 0 $X=27940 $Y=52090
X33 1 VIA1_C_CDNS_56 $T=29400 52280 0 0 $X=29000 $Y=52090
X34 1 VIA1_C_CDNS_56 $T=30670 52280 0 0 $X=30270 $Y=52090
X35 1 VIA1_C_CDNS_56 $T=31940 52280 0 0 $X=31540 $Y=52090
X36 1 VIA1_C_CDNS_57 $T=2680 38940 0 0 $X=2540 $Y=38490
X37 1 VIA1_C_CDNS_57 $T=2680 65620 0 0 $X=2540 $Y=65170
X38 1 VIA1_C_CDNS_57 $T=4220 2290 0 0 $X=4080 $Y=1840
X39 1 VIA1_C_CDNS_57 $T=4220 34870 0 0 $X=4080 $Y=34420
X40 1 VIA1_C_CDNS_57 $T=5110 1065 0 0 $X=4970 $Y=615
X41 1 VIA1_C_CDNS_57 $T=5110 36095 0 0 $X=4970 $Y=35645
X42 1 VIA1_C_CDNS_57 $T=7800 65620 0 0 $X=7660 $Y=65170
X43 1 VIA1_C_CDNS_57 $T=9070 38940 0 0 $X=8930 $Y=38490
X44 1 VIA1_C_CDNS_57 $T=10340 65620 0 0 $X=10200 $Y=65170
X45 6 VIA1_C_CDNS_57 $T=11400 31030 0 0 $X=11260 $Y=30580
X46 1 VIA1_C_CDNS_57 $T=11400 65620 0 0 $X=11260 $Y=65170
X47 5 VIA1_C_CDNS_57 $T=12670 7410 0 0 $X=12530 $Y=6960
X48 6 VIA1_C_CDNS_57 $T=12670 41500 0 0 $X=12530 $Y=41050
X49 5 VIA1_C_CDNS_57 $T=13940 29750 0 0 $X=13800 $Y=29300
X50 6 VIA1_C_CDNS_57 $T=13940 63060 0 0 $X=13800 $Y=62610
X51 4 VIA1_C_CDNS_57 $T=15000 32310 0 0 $X=14860 $Y=31860
X52 1 VIA1_C_CDNS_57 $T=15000 65620 0 0 $X=14860 $Y=65170
X53 5 VIA1_C_CDNS_57 $T=16270 7410 0 0 $X=16130 $Y=6960
X54 6 VIA1_C_CDNS_57 $T=16270 41500 0 0 $X=16130 $Y=41050
X55 3 VIA1_C_CDNS_57 $T=17540 33590 0 0 $X=17400 $Y=33140
X56 4 VIA1_C_CDNS_57 $T=17540 64340 0 0 $X=17400 $Y=63890
X57 6 VIA1_C_CDNS_57 $T=18600 31030 0 0 $X=18460 $Y=30580
X58 1 VIA1_C_CDNS_57 $T=18600 65620 0 0 $X=18460 $Y=65170
X59 5 VIA1_C_CDNS_57 $T=19870 7410 0 0 $X=19730 $Y=6960
X60 6 VIA1_C_CDNS_57 $T=19870 41500 0 0 $X=19730 $Y=41050
X61 5 VIA1_C_CDNS_57 $T=21140 29750 0 0 $X=21000 $Y=29300
X62 6 VIA1_C_CDNS_57 $T=21140 63060 0 0 $X=21000 $Y=62610
X63 3 VIA1_C_CDNS_57 $T=22200 33590 0 0 $X=22060 $Y=33140
X64 4 VIA1_C_CDNS_57 $T=22200 64340 0 0 $X=22060 $Y=63890
X65 5 VIA1_C_CDNS_57 $T=23470 7410 0 0 $X=23330 $Y=6960
X66 6 VIA1_C_CDNS_57 $T=23470 41500 0 0 $X=23330 $Y=41050
X67 4 VIA1_C_CDNS_57 $T=24740 32310 0 0 $X=24600 $Y=31860
X68 1 VIA1_C_CDNS_57 $T=24740 65620 0 0 $X=24600 $Y=65170
X69 5 VIA1_C_CDNS_57 $T=25800 29750 0 0 $X=25660 $Y=29300
X70 6 VIA1_C_CDNS_57 $T=25800 63060 0 0 $X=25660 $Y=62610
X71 5 VIA1_C_CDNS_57 $T=27070 7410 0 0 $X=26930 $Y=6960
X72 6 VIA1_C_CDNS_57 $T=27070 41500 0 0 $X=26930 $Y=41050
X73 6 VIA1_C_CDNS_57 $T=28340 31030 0 0 $X=28200 $Y=30580
X74 1 VIA1_C_CDNS_57 $T=28340 65620 0 0 $X=28200 $Y=65170
X75 1 VIA1_C_CDNS_57 $T=29400 65620 0 0 $X=29260 $Y=65170
X76 1 VIA1_C_CDNS_57 $T=30670 38940 0 0 $X=30530 $Y=38490
X77 1 VIA1_C_CDNS_57 $T=31940 65620 0 0 $X=31800 $Y=65170
X78 1 VIA1_C_CDNS_57 $T=34630 1065 0 0 $X=34490 $Y=615
X79 1 VIA1_C_CDNS_57 $T=34630 36095 0 0 $X=34490 $Y=35645
X80 1 VIA1_C_CDNS_57 $T=35520 2290 0 0 $X=35380 $Y=1840
X81 1 VIA1_C_CDNS_57 $T=35520 34870 0 0 $X=35380 $Y=34420
X82 1 VIA1_C_CDNS_57 $T=37060 38940 0 0 $X=36920 $Y=38490
X83 1 VIA1_C_CDNS_57 $T=37060 65620 0 0 $X=36920 $Y=65170
X84 1 VIA2_C_CDNS_58 $T=4070 38940 0 0 $X=3620 $Y=38540
X85 1 VIA2_C_CDNS_58 $T=4070 65620 0 0 $X=3620 $Y=65220
X86 1 VIA2_C_CDNS_58 $T=5110 2290 0 0 $X=4660 $Y=1890
X87 1 VIA2_C_CDNS_58 $T=5110 34870 0 0 $X=4660 $Y=34470
X88 4 VIA2_C_CDNS_58 $T=5350 40220 0 0 $X=4900 $Y=39820
X89 4 VIA2_C_CDNS_58 $T=5350 64340 0 0 $X=4900 $Y=63940
X90 3 VIA2_C_CDNS_58 $T=6390 3570 0 0 $X=5940 $Y=3170
X91 3 VIA2_C_CDNS_58 $T=6390 33590 0 0 $X=5940 $Y=33190
X92 6 VIA2_C_CDNS_58 $T=6630 41500 0 0 $X=6180 $Y=41100
X93 6 VIA2_C_CDNS_58 $T=6630 63060 0 0 $X=6180 $Y=62660
X94 4 VIA2_C_CDNS_58 $T=7670 4850 0 0 $X=7220 $Y=4450
X95 4 VIA2_C_CDNS_58 $T=7670 32310 0 0 $X=7220 $Y=31910
X96 6 VIA2_C_CDNS_58 $T=8950 6130 0 0 $X=8500 $Y=5730
X97 6 VIA2_C_CDNS_58 $T=8950 31030 0 0 $X=8500 $Y=30630
X98 5 VIA2_C_CDNS_58 $T=10230 7410 0 0 $X=9780 $Y=7010
X99 5 VIA2_C_CDNS_58 $T=10230 29750 0 0 $X=9780 $Y=29350
X100 5 VIA2_C_CDNS_58 $T=29510 7410 0 0 $X=29060 $Y=7010
X101 5 VIA2_C_CDNS_58 $T=29510 29750 0 0 $X=29060 $Y=29350
X102 6 VIA2_C_CDNS_58 $T=30790 6130 0 0 $X=30340 $Y=5730
X103 6 VIA2_C_CDNS_58 $T=30790 31030 0 0 $X=30340 $Y=30630
X104 4 VIA2_C_CDNS_58 $T=32070 4850 0 0 $X=31620 $Y=4450
X105 4 VIA2_C_CDNS_58 $T=32070 32310 0 0 $X=31620 $Y=31910
X106 6 VIA2_C_CDNS_58 $T=33110 41500 0 0 $X=32660 $Y=41100
X107 6 VIA2_C_CDNS_58 $T=33110 63060 0 0 $X=32660 $Y=62660
X108 3 VIA2_C_CDNS_58 $T=33350 3570 0 0 $X=32900 $Y=3170
X109 3 VIA2_C_CDNS_58 $T=33350 33590 0 0 $X=32900 $Y=33190
X110 4 VIA2_C_CDNS_58 $T=34390 40220 0 0 $X=33940 $Y=39820
X111 4 VIA2_C_CDNS_58 $T=34390 64340 0 0 $X=33940 $Y=63940
X112 1 VIA2_C_CDNS_58 $T=34630 2290 0 0 $X=34180 $Y=1890
X113 1 VIA2_C_CDNS_58 $T=34630 34870 0 0 $X=34180 $Y=34470
X114 1 VIA2_C_CDNS_58 $T=35670 38940 0 0 $X=35220 $Y=38540
X115 1 VIA2_C_CDNS_58 $T=35670 65620 0 0 $X=35220 $Y=65220
X116 1 VIA2_C_CDNS_59 $T=4070 52280 0 0 $X=3670 $Y=52090
X117 4 VIA2_C_CDNS_59 $T=5350 51500 0 0 $X=4950 $Y=51310
X118 3 VIA2_C_CDNS_59 $T=6390 17410 0 0 $X=5990 $Y=17220
X119 6 VIA2_C_CDNS_59 $T=6630 53060 0 0 $X=6230 $Y=52870
X120 4 VIA2_C_CDNS_59 $T=7670 18190 0 0 $X=7270 $Y=18000
X121 6 VIA2_C_CDNS_59 $T=8950 18970 0 0 $X=8550 $Y=18780
X122 5 VIA2_C_CDNS_59 $T=10230 19750 0 0 $X=9830 $Y=19560
X123 5 VIA2_C_CDNS_59 $T=29510 19750 0 0 $X=29110 $Y=19560
X124 6 VIA2_C_CDNS_59 $T=30790 18970 0 0 $X=30390 $Y=18780
X125 4 VIA2_C_CDNS_59 $T=32070 18190 0 0 $X=31670 $Y=18000
X126 6 VIA2_C_CDNS_59 $T=33110 53060 0 0 $X=32710 $Y=52870
X127 3 VIA2_C_CDNS_59 $T=33350 17410 0 0 $X=32950 $Y=17220
X128 4 VIA2_C_CDNS_59 $T=34390 51500 0 0 $X=33990 $Y=51310
X129 1 VIA2_C_CDNS_60 $T=5110 35760 1 0 $X=4970 $Y=35220
X130 1 VIA2_C_CDNS_60 $T=34630 35760 1 0 $X=34490 $Y=35220
X131 1 VIA2_C_CDNS_61 $T=5110 1400 1 0 $X=4970 $Y=1210
X132 1 VIA2_C_CDNS_61 $T=34630 1400 1 0 $X=34490 $Y=1210
X133 1 VIA2_C_CDNS_62 $T=4070 37540 0 0 $X=3620 $Y=37400
X134 1 VIA2_C_CDNS_62 $T=4070 67020 0 0 $X=3620 $Y=66880
X135 1 VIA2_C_CDNS_62 $T=35670 37540 0 0 $X=35220 $Y=37400
X136 1 VIA2_C_CDNS_62 $T=35670 52280 0 0 $X=35220 $Y=52140
X137 1 VIA2_C_CDNS_62 $T=35670 67020 0 0 $X=35220 $Y=66880
X138 1 VIA1_C_CDNS_63 $T=4070 37540 0 0 $X=3620 $Y=37400
X139 1 VIA1_C_CDNS_63 $T=4070 67020 0 0 $X=3620 $Y=66880
X140 1 VIA1_C_CDNS_63 $T=35670 37540 0 0 $X=35220 $Y=37400
X141 1 VIA1_C_CDNS_63 $T=35670 67020 0 0 $X=35220 $Y=66880
X142 1 VIA1_C_CDNS_64 $T=2680 52280 0 0 $X=2540 $Y=52090
X143 1 VIA1_C_CDNS_64 $T=37060 52280 0 0 $X=36920 $Y=52090
X144 5 VIA2_C_CDNS_65 $T=10230 28395 0 0 $X=9730 $Y=28145
X145 6 VIA2_C_CDNS_66 $T=18620 31030 0 0 $X=18120 $Y=30530
X146 6 VIA2_C_CDNS_66 $T=18620 41500 0 0 $X=18120 $Y=41000
X147 4 VIA2_C_CDNS_66 $T=21070 32310 0 0 $X=20570 $Y=31810
X148 4 VIA2_C_CDNS_66 $T=21070 40220 0 0 $X=20570 $Y=39720
X149 5 VIA1_C_CDNS_67 $T=1850 28395 0 0 $X=890 $Y=28145
X150 1 1 1 1 ne3_CDNS_68 $T=8070 50710 1 0 $X=7270 $Y=42140
X151 1 1 1 1 ne3_CDNS_68 $T=8070 62020 1 0 $X=7270 $Y=53450
X152 4 5 3 1 ne3_CDNS_68 $T=11670 16620 1 0 $X=10870 $Y=8050
X153 6 5 5 1 ne3_CDNS_68 $T=11670 28710 1 0 $X=10870 $Y=20140
X154 1 6 4 1 ne3_CDNS_68 $T=11670 50710 1 0 $X=10870 $Y=42140
X155 1 6 6 1 ne3_CDNS_68 $T=11670 62020 1 0 $X=10870 $Y=53450
X156 6 5 5 1 ne3_CDNS_68 $T=15270 16620 1 0 $X=14470 $Y=8050
X157 4 5 3 1 ne3_CDNS_68 $T=15270 28710 1 0 $X=14470 $Y=20140
X158 1 6 6 1 ne3_CDNS_68 $T=15270 50710 1 0 $X=14470 $Y=42140
X159 1 6 4 1 ne3_CDNS_68 $T=15270 62020 1 0 $X=14470 $Y=53450
X160 4 5 3 1 ne3_CDNS_68 $T=18870 16620 1 0 $X=18070 $Y=8050
X161 6 5 5 1 ne3_CDNS_68 $T=18870 28710 1 0 $X=18070 $Y=20140
X162 1 6 4 1 ne3_CDNS_68 $T=18870 50710 1 0 $X=18070 $Y=42140
X163 1 6 6 1 ne3_CDNS_68 $T=18870 62020 1 0 $X=18070 $Y=53450
X164 6 5 5 1 ne3_CDNS_68 $T=24470 16620 0 180 $X=21670 $Y=8050
X165 4 5 3 1 ne3_CDNS_68 $T=24470 28710 0 180 $X=21670 $Y=20140
X166 1 6 6 1 ne3_CDNS_68 $T=24470 50710 0 180 $X=21670 $Y=42140
X167 1 6 4 1 ne3_CDNS_68 $T=24470 62020 0 180 $X=21670 $Y=53450
X168 4 5 3 1 ne3_CDNS_68 $T=28070 16620 0 180 $X=25270 $Y=8050
X169 6 5 5 1 ne3_CDNS_68 $T=28070 28710 0 180 $X=25270 $Y=20140
X170 1 6 4 1 ne3_CDNS_68 $T=28070 50710 0 180 $X=25270 $Y=42140
X171 1 6 6 1 ne3_CDNS_68 $T=28070 62020 0 180 $X=25270 $Y=53450
X172 1 1 1 1 ne3_CDNS_68 $T=29670 50710 1 0 $X=28870 $Y=42140
X173 1 1 1 1 ne3_CDNS_68 $T=29670 62020 1 0 $X=28870 $Y=53450
X174 2 5 1 rpp1k1_CDNS_69 $T=850 7670 1 90 $X=630 $Y=6730
.ends Ext_Iref_ST

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_77                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_77 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_77

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_70                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_70 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_70

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_71                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_71 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_71

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_72                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_72 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_72

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_73                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_73 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_73

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: P1_C_CDNS_74                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt P1_C_CDNS_74 1
** N=1 EP=1 FDC=0
.ends P1_C_CDNS_74

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_76                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_76 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_76

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_78                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_78 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_78

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_79                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_79 1 2 3 4 5
*.DEVICECLIMB
** N=5 EP=5 FDC=8
M0 3 2 1 4 pe3 L=3e-07 W=2e-06 AD=5.4e-13 AS=9.6e-13 PD=2.54e-06 PS=4.96e-06 $X=0 $Y=0 $dt=86
M1 1 2 3 4 pe3 L=3e-07 W=2e-06 AD=5.4e-13 AS=5.4e-13 PD=2.54e-06 PS=2.54e-06 $X=840 $Y=0 $dt=86
M2 3 2 1 4 pe3 L=3e-07 W=2e-06 AD=5.4e-13 AS=5.4e-13 PD=2.54e-06 PS=2.54e-06 $X=1680 $Y=0 $dt=86
M3 1 2 3 4 pe3 L=3e-07 W=2e-06 AD=5.4e-13 AS=5.4e-13 PD=2.54e-06 PS=2.54e-06 $X=2520 $Y=0 $dt=86
M4 3 2 1 4 pe3 L=3e-07 W=2e-06 AD=5.4e-13 AS=5.4e-13 PD=2.54e-06 PS=2.54e-06 $X=3360 $Y=0 $dt=86
M5 1 2 3 4 pe3 L=3e-07 W=2e-06 AD=5.4e-13 AS=5.4e-13 PD=2.54e-06 PS=2.54e-06 $X=4200 $Y=0 $dt=86
M6 3 2 1 4 pe3 L=3e-07 W=2e-06 AD=5.4e-13 AS=5.4e-13 PD=2.54e-06 PS=2.54e-06 $X=5040 $Y=0 $dt=86
M7 1 2 3 4 pe3 L=3e-07 W=2e-06 AD=9.6e-13 AS=5.4e-13 PD=4.96e-06 PS=2.54e-06 $X=5880 $Y=0 $dt=86
.ends pe3_CDNS_79

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_80                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_80 1 2 3 4 5
*.DEVICECLIMB
** N=5 EP=5 FDC=1
M0 3 2 1 4 pe3 L=2e-06 W=6e-06 AD=2.88e-12 AS=2.88e-12 PD=1.296e-05 PS=1.296e-05 $X=0 $Y=0 $dt=86
.ends pe3_CDNS_80

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: MASCO__A45                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt MASCO__A45 1 2 3 4 5 6 7 8 9
*.DEVICECLIMB
** N=9 EP=9 FDC=4
X0 4 1 5 8 9 pe3_CDNS_80 $T=3510 1030 1 180 $X=0 $Y=0
X1 2 1 3 8 9 pe3_CDNS_80 $T=8530 1030 1 180 $X=5020 $Y=0
X2 6 1 7 8 9 pe3_CDNS_80 $T=13550 1030 1 180 $X=10040 $Y=0
X3 2 1 3 8 9 pe3_CDNS_80 $T=18570 1030 1 180 $X=15060 $Y=0
.ends MASCO__A45

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: Idac_5bit_ST_V3                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt Idac_5bit_ST_V3 1 2 3 4 5 6 7 8 9
** N=20 EP=9 FDC=316
X0 10 VIA2_C_CDNS_47 $T=92165 128520 0 0 $X=91415 $Y=127770
X1 10 VIA2_C_CDNS_47 $T=92165 157065 0 0 $X=91415 $Y=156315
X2 11 VIA2_C_CDNS_47 $T=92765 32800 0 0 $X=92015 $Y=32050
X3 12 VIA2_C_CDNS_47 $T=94745 132080 0 0 $X=93995 $Y=131330
X4 12 VIA2_C_CDNS_47 $T=94745 158845 0 0 $X=93995 $Y=158095
X5 13 VIA2_C_CDNS_47 $T=95505 36360 0 0 $X=94755 $Y=35610
X6 14 VIA2_C_CDNS_47 $T=97325 135640 0 0 $X=96575 $Y=134890
X7 14 VIA2_C_CDNS_47 $T=97325 160625 0 0 $X=96575 $Y=159875
X8 15 VIA2_C_CDNS_47 $T=98245 39920 0 0 $X=97495 $Y=39170
X9 16 VIA2_C_CDNS_47 $T=99905 139200 0 0 $X=99155 $Y=138450
X10 16 VIA2_C_CDNS_47 $T=99905 162405 0 0 $X=99155 $Y=161655
X11 17 VIA2_C_CDNS_47 $T=100985 43480 0 0 $X=100235 $Y=42730
X12 18 VIA2_C_CDNS_47 $T=102485 142760 0 0 $X=101735 $Y=142010
X13 18 VIA2_C_CDNS_47 $T=102485 164185 0 0 $X=101735 $Y=163435
X14 19 VIA2_C_CDNS_47 $T=103725 47040 0 0 $X=102975 $Y=46290
X15 20 VIA2_C_CDNS_47 $T=105125 144540 0 0 $X=104375 $Y=143790
X16 20 VIA2_C_CDNS_47 $T=105125 155285 0 0 $X=104375 $Y=154535
X17 11 VIA2_C_CDNS_48 $T=92765 14505 0 0 $X=92015 $Y=14015
X18 13 VIA2_C_CDNS_48 $T=95505 15785 0 0 $X=94755 $Y=15295
X19 15 VIA2_C_CDNS_48 $T=98250 17065 0 0 $X=97500 $Y=16575
X20 17 VIA2_C_CDNS_48 $T=100985 18345 0 0 $X=100235 $Y=17855
X21 19 VIA2_C_CDNS_48 $T=103725 19625 0 0 $X=102975 $Y=19135
X22 11 VIA1_C_CDNS_57 $T=76630 14505 0 0 $X=76490 $Y=14055
X23 4 VIA1_C_CDNS_57 $T=77050 4045 0 0 $X=76910 $Y=3595
X24 5 VIA1_C_CDNS_57 $T=77470 20905 0 0 $X=77330 $Y=20455
X25 4 VIA1_C_CDNS_57 $T=77890 4045 0 0 $X=77750 $Y=3595
X26 11 VIA1_C_CDNS_57 $T=78310 14505 0 0 $X=78170 $Y=14055
X27 4 VIA1_C_CDNS_57 $T=78730 4045 0 0 $X=78590 $Y=3595
X28 5 VIA1_C_CDNS_57 $T=79150 20905 0 0 $X=79010 $Y=20455
X29 4 VIA1_C_CDNS_57 $T=79570 4045 0 0 $X=79430 $Y=3595
X30 11 VIA1_C_CDNS_57 $T=79990 14505 0 0 $X=79850 $Y=14055
X31 4 VIA1_C_CDNS_57 $T=80410 4045 0 0 $X=80270 $Y=3595
X32 5 VIA1_C_CDNS_57 $T=80830 20905 0 0 $X=80690 $Y=20455
X33 4 VIA1_C_CDNS_57 $T=81250 4045 0 0 $X=81110 $Y=3595
X34 11 VIA1_C_CDNS_57 $T=81670 14505 0 0 $X=81530 $Y=14055
X35 4 VIA1_C_CDNS_57 $T=82090 4045 0 0 $X=81950 $Y=3595
X36 5 VIA1_C_CDNS_57 $T=82510 20905 0 0 $X=82370 $Y=20455
X37 4 VIA1_C_CDNS_57 $T=82930 4045 0 0 $X=82790 $Y=3595
X38 11 VIA1_C_CDNS_57 $T=83350 14505 0 0 $X=83210 $Y=14055
X39 13 VIA1_C_CDNS_57 $T=85830 15785 0 0 $X=85690 $Y=15335
X40 6 VIA1_C_CDNS_57 $T=86250 5325 0 0 $X=86110 $Y=4875
X41 5 VIA1_C_CDNS_57 $T=86670 20905 0 0 $X=86530 $Y=20455
X42 6 VIA1_C_CDNS_57 $T=87090 5325 0 0 $X=86950 $Y=4875
X43 13 VIA1_C_CDNS_57 $T=87510 15785 0 0 $X=87370 $Y=15335
X44 6 VIA1_C_CDNS_57 $T=87930 5325 0 0 $X=87790 $Y=4875
X45 5 VIA1_C_CDNS_57 $T=88350 20905 0 0 $X=88210 $Y=20455
X46 6 VIA1_C_CDNS_57 $T=88770 5325 0 0 $X=88630 $Y=4875
X47 13 VIA1_C_CDNS_57 $T=89190 15785 0 0 $X=89050 $Y=15335
X48 6 VIA1_C_CDNS_57 $T=89610 5325 0 0 $X=89470 $Y=4875
X49 5 VIA1_C_CDNS_57 $T=90030 20905 0 0 $X=89890 $Y=20455
X50 6 VIA1_C_CDNS_57 $T=90450 5325 0 0 $X=90310 $Y=4875
X51 13 VIA1_C_CDNS_57 $T=90870 15785 0 0 $X=90730 $Y=15335
X52 6 VIA1_C_CDNS_57 $T=91290 5325 0 0 $X=91150 $Y=4875
X53 5 VIA1_C_CDNS_57 $T=91710 20905 0 0 $X=91570 $Y=20455
X54 6 VIA1_C_CDNS_57 $T=92130 5325 0 0 $X=91990 $Y=4875
X55 13 VIA1_C_CDNS_57 $T=92550 15785 0 0 $X=92410 $Y=15335
X56 15 VIA1_C_CDNS_57 $T=95030 17065 0 0 $X=94890 $Y=16615
X57 7 VIA1_C_CDNS_57 $T=95450 6605 0 0 $X=95310 $Y=6155
X58 5 VIA1_C_CDNS_57 $T=95870 20905 0 0 $X=95730 $Y=20455
X59 7 VIA1_C_CDNS_57 $T=96290 6605 0 0 $X=96150 $Y=6155
X60 15 VIA1_C_CDNS_57 $T=96710 17065 0 0 $X=96570 $Y=16615
X61 7 VIA1_C_CDNS_57 $T=97130 6605 0 0 $X=96990 $Y=6155
X62 5 VIA1_C_CDNS_57 $T=97550 20905 0 0 $X=97410 $Y=20455
X63 7 VIA1_C_CDNS_57 $T=97970 6605 0 0 $X=97830 $Y=6155
X64 15 VIA1_C_CDNS_57 $T=98390 17065 0 0 $X=98250 $Y=16615
X65 7 VIA1_C_CDNS_57 $T=98810 6605 0 0 $X=98670 $Y=6155
X66 5 VIA1_C_CDNS_57 $T=99230 20905 0 0 $X=99090 $Y=20455
X67 7 VIA1_C_CDNS_57 $T=99650 6605 0 0 $X=99510 $Y=6155
X68 15 VIA1_C_CDNS_57 $T=100070 17065 0 0 $X=99930 $Y=16615
X69 7 VIA1_C_CDNS_57 $T=100490 6605 0 0 $X=100350 $Y=6155
X70 5 VIA1_C_CDNS_57 $T=100910 20905 0 0 $X=100770 $Y=20455
X71 7 VIA1_C_CDNS_57 $T=101330 6605 0 0 $X=101190 $Y=6155
X72 15 VIA1_C_CDNS_57 $T=101750 17065 0 0 $X=101610 $Y=16615
X73 17 VIA1_C_CDNS_57 $T=104230 18345 0 0 $X=104090 $Y=17895
X74 8 VIA1_C_CDNS_57 $T=104650 7885 0 0 $X=104510 $Y=7435
X75 5 VIA1_C_CDNS_57 $T=105070 20905 0 0 $X=104930 $Y=20455
X76 8 VIA1_C_CDNS_57 $T=105490 7885 0 0 $X=105350 $Y=7435
X77 17 VIA1_C_CDNS_57 $T=105910 18345 0 0 $X=105770 $Y=17895
X78 8 VIA1_C_CDNS_57 $T=106330 7885 0 0 $X=106190 $Y=7435
X79 5 VIA1_C_CDNS_57 $T=106750 20905 0 0 $X=106610 $Y=20455
X80 8 VIA1_C_CDNS_57 $T=107170 7885 0 0 $X=107030 $Y=7435
X81 17 VIA1_C_CDNS_57 $T=107590 18345 0 0 $X=107450 $Y=17895
X82 8 VIA1_C_CDNS_57 $T=108010 7885 0 0 $X=107870 $Y=7435
X83 5 VIA1_C_CDNS_57 $T=108430 20905 0 0 $X=108290 $Y=20455
X84 8 VIA1_C_CDNS_57 $T=108850 7885 0 0 $X=108710 $Y=7435
X85 17 VIA1_C_CDNS_57 $T=109270 18345 0 0 $X=109130 $Y=17895
X86 8 VIA1_C_CDNS_57 $T=109690 7885 0 0 $X=109550 $Y=7435
X87 5 VIA1_C_CDNS_57 $T=110110 20905 0 0 $X=109970 $Y=20455
X88 8 VIA1_C_CDNS_57 $T=110530 7885 0 0 $X=110390 $Y=7435
X89 17 VIA1_C_CDNS_57 $T=110950 18345 0 0 $X=110810 $Y=17895
X90 19 VIA1_C_CDNS_57 $T=113430 19625 0 0 $X=113290 $Y=19175
X91 9 VIA1_C_CDNS_57 $T=113850 9165 0 0 $X=113710 $Y=8715
X92 5 VIA1_C_CDNS_57 $T=114270 20905 0 0 $X=114130 $Y=20455
X93 9 VIA1_C_CDNS_57 $T=114690 9165 0 0 $X=114550 $Y=8715
X94 19 VIA1_C_CDNS_57 $T=115110 19625 0 0 $X=114970 $Y=19175
X95 9 VIA1_C_CDNS_57 $T=115530 9165 0 0 $X=115390 $Y=8715
X96 5 VIA1_C_CDNS_57 $T=115950 20905 0 0 $X=115810 $Y=20455
X97 9 VIA1_C_CDNS_57 $T=116370 9165 0 0 $X=116230 $Y=8715
X98 19 VIA1_C_CDNS_57 $T=116790 19625 0 0 $X=116650 $Y=19175
X99 9 VIA1_C_CDNS_57 $T=117210 9165 0 0 $X=117070 $Y=8715
X100 5 VIA1_C_CDNS_57 $T=117630 20905 0 0 $X=117490 $Y=20455
X101 9 VIA1_C_CDNS_57 $T=118050 9165 0 0 $X=117910 $Y=8715
X102 19 VIA1_C_CDNS_57 $T=118470 19625 0 0 $X=118330 $Y=19175
X103 9 VIA1_C_CDNS_57 $T=118890 9165 0 0 $X=118750 $Y=8715
X104 5 VIA1_C_CDNS_57 $T=119310 20905 0 0 $X=119170 $Y=20455
X105 9 VIA1_C_CDNS_57 $T=119730 9165 0 0 $X=119590 $Y=8715
X106 19 VIA1_C_CDNS_57 $T=120150 19625 0 0 $X=120010 $Y=19175
X107 5 VIA2_C_CDNS_58 $T=68350 2765 0 0 $X=67900 $Y=2365
X108 5 VIA2_C_CDNS_58 $T=68350 20905 0 0 $X=67900 $Y=20505
X109 4 VIA2_C_CDNS_58 $T=69630 4045 0 0 $X=69180 $Y=3645
X110 6 VIA2_C_CDNS_58 $T=70910 5325 0 0 $X=70460 $Y=4925
X111 7 VIA2_C_CDNS_58 $T=72190 6605 0 0 $X=71740 $Y=6205
X112 8 VIA2_C_CDNS_58 $T=73470 7885 0 0 $X=73020 $Y=7485
X113 9 VIA2_C_CDNS_58 $T=74750 9165 0 0 $X=74300 $Y=8765
X114 9 VIA2_C_CDNS_58 $T=122030 9165 0 0 $X=121580 $Y=8765
X115 8 VIA2_C_CDNS_58 $T=123310 7885 0 0 $X=122860 $Y=7485
X116 7 VIA2_C_CDNS_58 $T=124590 6605 0 0 $X=124140 $Y=6205
X117 6 VIA2_C_CDNS_58 $T=125870 5325 0 0 $X=125420 $Y=4925
X118 4 VIA2_C_CDNS_58 $T=127150 4045 0 0 $X=126700 $Y=3645
X119 5 VIA2_C_CDNS_58 $T=128430 2765 0 0 $X=127980 $Y=2365
X120 5 VIA2_C_CDNS_58 $T=128430 20905 0 0 $X=127980 $Y=20505
X121 2 VIA1_C_CDNS_70 $T=14060 153505 0 0 $X=13920 $Y=152795
X122 2 VIA1_C_CDNS_70 $T=15330 231565 0 0 $X=15190 $Y=230855
X123 2 VIA1_C_CDNS_70 $T=16600 153505 0 0 $X=16460 $Y=152795
X124 18 VIA1_C_CDNS_70 $T=18640 48820 0 0 $X=18500 $Y=48110
X125 2 VIA1_C_CDNS_70 $T=19080 153505 0 0 $X=18940 $Y=152795
X126 3 VIA1_C_CDNS_70 $T=19910 124960 0 0 $X=19770 $Y=124250
X127 20 VIA1_C_CDNS_70 $T=20350 220885 0 0 $X=20210 $Y=220175
X128 19 VIA1_C_CDNS_70 $T=21180 47040 0 0 $X=21040 $Y=46330
X129 18 VIA1_C_CDNS_70 $T=21620 164185 0 0 $X=21480 $Y=163475
X130 18 VIA1_C_CDNS_70 $T=23660 48820 0 0 $X=23520 $Y=48110
X131 2 VIA1_C_CDNS_70 $T=24100 153505 0 0 $X=23960 $Y=152795
X132 3 VIA1_C_CDNS_70 $T=24930 124960 0 0 $X=24790 $Y=124250
X133 20 VIA1_C_CDNS_70 $T=25370 220885 0 0 $X=25230 $Y=220175
X134 19 VIA1_C_CDNS_70 $T=26200 47040 0 0 $X=26060 $Y=46330
X135 18 VIA1_C_CDNS_70 $T=26640 164185 0 0 $X=26500 $Y=163475
X136 18 VIA1_C_CDNS_70 $T=28680 48820 0 0 $X=28540 $Y=48110
X137 2 VIA1_C_CDNS_70 $T=29120 153505 0 0 $X=28980 $Y=152795
X138 3 VIA1_C_CDNS_70 $T=29950 124960 0 0 $X=29810 $Y=124250
X139 20 VIA1_C_CDNS_70 $T=30390 220885 0 0 $X=30250 $Y=220175
X140 19 VIA1_C_CDNS_70 $T=31220 47040 0 0 $X=31080 $Y=46330
X141 18 VIA1_C_CDNS_70 $T=31660 164185 0 0 $X=31520 $Y=163475
X142 18 VIA1_C_CDNS_70 $T=33700 48820 0 0 $X=33560 $Y=48110
X143 2 VIA1_C_CDNS_70 $T=34140 153505 0 0 $X=34000 $Y=152795
X144 3 VIA1_C_CDNS_70 $T=34970 124960 0 0 $X=34830 $Y=124250
X145 20 VIA1_C_CDNS_70 $T=35410 220885 0 0 $X=35270 $Y=220175
X146 19 VIA1_C_CDNS_70 $T=36240 47040 0 0 $X=36100 $Y=46330
X147 18 VIA1_C_CDNS_70 $T=36680 164185 0 0 $X=36540 $Y=163475
X148 18 VIA1_C_CDNS_70 $T=38720 48820 0 0 $X=38580 $Y=48110
X149 2 VIA1_C_CDNS_70 $T=39160 153505 0 0 $X=39020 $Y=152795
X150 3 VIA1_C_CDNS_70 $T=39990 124960 0 0 $X=39850 $Y=124250
X151 20 VIA1_C_CDNS_70 $T=40430 220885 0 0 $X=40290 $Y=220175
X152 19 VIA1_C_CDNS_70 $T=41260 47040 0 0 $X=41120 $Y=46330
X153 18 VIA1_C_CDNS_70 $T=41700 164185 0 0 $X=41560 $Y=163475
X154 18 VIA1_C_CDNS_70 $T=43740 48820 0 0 $X=43600 $Y=48110
X155 2 VIA1_C_CDNS_70 $T=44180 153505 0 0 $X=44040 $Y=152795
X156 3 VIA1_C_CDNS_70 $T=45010 124960 0 0 $X=44870 $Y=124250
X157 20 VIA1_C_CDNS_70 $T=45450 220885 0 0 $X=45310 $Y=220175
X158 19 VIA1_C_CDNS_70 $T=46280 47040 0 0 $X=46140 $Y=46330
X159 18 VIA1_C_CDNS_70 $T=46720 164185 0 0 $X=46580 $Y=163475
X160 18 VIA1_C_CDNS_70 $T=48760 48820 0 0 $X=48620 $Y=48110
X161 2 VIA1_C_CDNS_70 $T=49200 153505 0 0 $X=49060 $Y=152795
X162 3 VIA1_C_CDNS_70 $T=50030 124960 0 0 $X=49890 $Y=124250
X163 20 VIA1_C_CDNS_70 $T=50470 220885 0 0 $X=50330 $Y=220175
X164 19 VIA1_C_CDNS_70 $T=51300 47040 0 0 $X=51160 $Y=46330
X165 18 VIA1_C_CDNS_70 $T=51740 164185 0 0 $X=51600 $Y=163475
X166 18 VIA1_C_CDNS_70 $T=53780 48820 0 0 $X=53640 $Y=48110
X167 2 VIA1_C_CDNS_70 $T=54220 153505 0 0 $X=54080 $Y=152795
X168 3 VIA1_C_CDNS_70 $T=55050 124960 0 0 $X=54910 $Y=124250
X169 19 VIA1_C_CDNS_70 $T=56320 47040 0 0 $X=56180 $Y=46330
X170 18 VIA1_C_CDNS_70 $T=56760 164185 0 0 $X=56620 $Y=163475
X171 18 VIA1_C_CDNS_70 $T=58800 48820 0 0 $X=58660 $Y=48110
X172 2 VIA1_C_CDNS_70 $T=59240 153505 0 0 $X=59100 $Y=152795
X173 3 VIA1_C_CDNS_70 $T=60070 124960 0 0 $X=59930 $Y=124250
X174 20 VIA1_C_CDNS_70 $T=60510 155285 0 0 $X=60370 $Y=154575
X175 20 VIA1_C_CDNS_70 $T=60510 220885 0 0 $X=60370 $Y=220175
X176 19 VIA1_C_CDNS_70 $T=61340 47040 0 0 $X=61200 $Y=46330
X177 18 VIA1_C_CDNS_70 $T=61780 164185 0 0 $X=61640 $Y=163475
X178 18 VIA1_C_CDNS_70 $T=63820 48820 0 0 $X=63680 $Y=48110
X179 2 VIA1_C_CDNS_70 $T=64260 153505 0 0 $X=64120 $Y=152795
X180 3 VIA1_C_CDNS_70 $T=65090 124960 0 0 $X=64950 $Y=124250
X181 20 VIA1_C_CDNS_70 $T=65530 220885 0 0 $X=65390 $Y=220175
X182 19 VIA1_C_CDNS_70 $T=66360 47040 0 0 $X=66220 $Y=46330
X183 18 VIA1_C_CDNS_70 $T=66800 164185 0 0 $X=66660 $Y=163475
X184 18 VIA1_C_CDNS_70 $T=68840 48820 0 0 $X=68700 $Y=48110
X185 2 VIA1_C_CDNS_70 $T=69280 153505 0 0 $X=69140 $Y=152795
X186 3 VIA1_C_CDNS_70 $T=70110 124960 0 0 $X=69970 $Y=124250
X187 20 VIA1_C_CDNS_70 $T=70550 220885 0 0 $X=70410 $Y=220175
X188 19 VIA1_C_CDNS_70 $T=71380 47040 0 0 $X=71240 $Y=46330
X189 18 VIA1_C_CDNS_70 $T=71820 164185 0 0 $X=71680 $Y=163475
X190 18 VIA1_C_CDNS_70 $T=73860 48820 0 0 $X=73720 $Y=48110
X191 2 VIA1_C_CDNS_70 $T=74300 153505 0 0 $X=74160 $Y=152795
X192 3 VIA1_C_CDNS_70 $T=75130 124960 0 0 $X=74990 $Y=124250
X193 20 VIA1_C_CDNS_70 $T=75570 220885 0 0 $X=75430 $Y=220175
X194 19 VIA1_C_CDNS_70 $T=76400 47040 0 0 $X=76260 $Y=46330
X195 18 VIA1_C_CDNS_70 $T=76840 164185 0 0 $X=76700 $Y=163475
X196 18 VIA1_C_CDNS_70 $T=78880 48820 0 0 $X=78740 $Y=48110
X197 2 VIA1_C_CDNS_70 $T=79320 153505 0 0 $X=79180 $Y=152795
X198 3 VIA1_C_CDNS_70 $T=80150 124960 0 0 $X=80010 $Y=124250
X199 20 VIA1_C_CDNS_70 $T=80590 220885 0 0 $X=80450 $Y=220175
X200 19 VIA1_C_CDNS_70 $T=81420 47040 0 0 $X=81280 $Y=46330
X201 18 VIA1_C_CDNS_70 $T=81860 164185 0 0 $X=81720 $Y=163475
X202 16 VIA1_C_CDNS_70 $T=83900 45260 0 0 $X=83760 $Y=44550
X203 2 VIA1_C_CDNS_70 $T=84340 153505 0 0 $X=84200 $Y=152795
X204 3 VIA1_C_CDNS_70 $T=85170 124960 0 0 $X=85030 $Y=124250
X205 20 VIA1_C_CDNS_70 $T=85610 220885 0 0 $X=85470 $Y=220175
X206 17 VIA1_C_CDNS_70 $T=86440 43480 0 0 $X=86300 $Y=42770
X207 16 VIA1_C_CDNS_70 $T=86880 162405 0 0 $X=86740 $Y=161695
X208 10 VIA1_C_CDNS_70 $T=88920 34580 0 0 $X=88780 $Y=33870
X209 2 VIA1_C_CDNS_70 $T=89360 153505 0 0 $X=89220 $Y=152795
X210 3 VIA1_C_CDNS_70 $T=90190 124960 0 0 $X=90050 $Y=124250
X211 20 VIA1_C_CDNS_70 $T=90630 220885 0 0 $X=90490 $Y=220175
X212 11 VIA1_C_CDNS_70 $T=91460 32800 0 0 $X=91320 $Y=32090
X213 10 VIA1_C_CDNS_70 $T=91900 157065 0 0 $X=91760 $Y=156355
X214 12 VIA1_C_CDNS_70 $T=93940 38140 0 0 $X=93800 $Y=37430
X215 2 VIA1_C_CDNS_70 $T=94380 153505 0 0 $X=94240 $Y=152795
X216 3 VIA1_C_CDNS_70 $T=95210 124960 0 0 $X=95070 $Y=124250
X217 20 VIA1_C_CDNS_70 $T=95650 220885 0 0 $X=95510 $Y=220175
X218 13 VIA1_C_CDNS_70 $T=96480 36360 0 0 $X=96340 $Y=35650
X219 12 VIA1_C_CDNS_70 $T=96920 158845 0 0 $X=96780 $Y=158135
X220 12 VIA1_C_CDNS_70 $T=98960 38140 0 0 $X=98820 $Y=37430
X221 2 VIA1_C_CDNS_70 $T=99400 153505 0 0 $X=99260 $Y=152795
X222 3 VIA1_C_CDNS_70 $T=100230 29240 0 0 $X=100090 $Y=28530
X223 3 VIA1_C_CDNS_70 $T=100230 124960 0 0 $X=100090 $Y=124250
X224 13 VIA1_C_CDNS_70 $T=101500 36360 0 0 $X=101360 $Y=35650
X225 12 VIA1_C_CDNS_70 $T=101940 158845 0 0 $X=101800 $Y=158135
X226 11 VIA1_C_CDNS_70 $T=103980 32800 0 0 $X=103840 $Y=32090
X227 10 VIA1_C_CDNS_70 $T=104420 157065 0 0 $X=104280 $Y=156355
X228 3 VIA1_C_CDNS_70 $T=105250 124960 0 0 $X=105110 $Y=124250
X229 20 VIA1_C_CDNS_70 $T=105690 220885 0 0 $X=105550 $Y=220175
X230 10 VIA1_C_CDNS_70 $T=106520 34580 0 0 $X=106380 $Y=33870
X231 2 VIA1_C_CDNS_70 $T=106960 153505 0 0 $X=106820 $Y=152795
X232 17 VIA1_C_CDNS_70 $T=109000 43480 0 0 $X=108860 $Y=42770
X233 16 VIA1_C_CDNS_70 $T=109440 162405 0 0 $X=109300 $Y=161695
X234 3 VIA1_C_CDNS_70 $T=110270 124960 0 0 $X=110130 $Y=124250
X235 20 VIA1_C_CDNS_70 $T=110710 220885 0 0 $X=110570 $Y=220175
X236 16 VIA1_C_CDNS_70 $T=111540 45260 0 0 $X=111400 $Y=44550
X237 2 VIA1_C_CDNS_70 $T=111980 153505 0 0 $X=111840 $Y=152795
X238 19 VIA1_C_CDNS_70 $T=114020 47040 0 0 $X=113880 $Y=46330
X239 18 VIA1_C_CDNS_70 $T=114460 164185 0 0 $X=114320 $Y=163475
X240 3 VIA1_C_CDNS_70 $T=115290 124960 0 0 $X=115150 $Y=124250
X241 20 VIA1_C_CDNS_70 $T=115730 220885 0 0 $X=115590 $Y=220175
X242 18 VIA1_C_CDNS_70 $T=116560 48820 0 0 $X=116420 $Y=48110
X243 2 VIA1_C_CDNS_70 $T=117000 153505 0 0 $X=116860 $Y=152795
X244 19 VIA1_C_CDNS_70 $T=119040 47040 0 0 $X=118900 $Y=46330
X245 18 VIA1_C_CDNS_70 $T=119480 164185 0 0 $X=119340 $Y=163475
X246 3 VIA1_C_CDNS_70 $T=120310 124960 0 0 $X=120170 $Y=124250
X247 20 VIA1_C_CDNS_70 $T=120750 220885 0 0 $X=120610 $Y=220175
X248 18 VIA1_C_CDNS_70 $T=121580 48820 0 0 $X=121440 $Y=48110
X249 2 VIA1_C_CDNS_70 $T=122020 153505 0 0 $X=121880 $Y=152795
X250 19 VIA1_C_CDNS_70 $T=124060 47040 0 0 $X=123920 $Y=46330
X251 18 VIA1_C_CDNS_70 $T=124500 164185 0 0 $X=124360 $Y=163475
X252 3 VIA1_C_CDNS_70 $T=125330 124960 0 0 $X=125190 $Y=124250
X253 20 VIA1_C_CDNS_70 $T=125770 220885 0 0 $X=125630 $Y=220175
X254 18 VIA1_C_CDNS_70 $T=126600 48820 0 0 $X=126460 $Y=48110
X255 2 VIA1_C_CDNS_70 $T=127040 153505 0 0 $X=126900 $Y=152795
X256 19 VIA1_C_CDNS_70 $T=129080 47040 0 0 $X=128940 $Y=46330
X257 18 VIA1_C_CDNS_70 $T=129520 164185 0 0 $X=129380 $Y=163475
X258 3 VIA1_C_CDNS_70 $T=130350 124960 0 0 $X=130210 $Y=124250
X259 20 VIA1_C_CDNS_70 $T=130790 220885 0 0 $X=130650 $Y=220175
X260 18 VIA1_C_CDNS_70 $T=131620 48820 0 0 $X=131480 $Y=48110
X261 2 VIA1_C_CDNS_70 $T=132060 153505 0 0 $X=131920 $Y=152795
X262 19 VIA1_C_CDNS_70 $T=134100 47040 0 0 $X=133960 $Y=46330
X263 2 VIA1_C_CDNS_70 $T=134540 153505 0 0 $X=134400 $Y=152795
X264 3 VIA1_C_CDNS_70 $T=135370 124960 0 0 $X=135230 $Y=124250
X265 20 VIA1_C_CDNS_70 $T=135810 220885 0 0 $X=135670 $Y=220175
X266 18 VIA1_C_CDNS_70 $T=136640 48820 0 0 $X=136500 $Y=48110
X267 18 VIA1_C_CDNS_70 $T=137080 164185 0 0 $X=136940 $Y=163475
X268 19 VIA1_C_CDNS_70 $T=139120 47040 0 0 $X=138980 $Y=46330
X269 2 VIA1_C_CDNS_70 $T=139560 153505 0 0 $X=139420 $Y=152795
X270 3 VIA1_C_CDNS_70 $T=140390 124960 0 0 $X=140250 $Y=124250
X271 20 VIA1_C_CDNS_70 $T=140830 220885 0 0 $X=140690 $Y=220175
X272 18 VIA1_C_CDNS_70 $T=141660 48820 0 0 $X=141520 $Y=48110
X273 18 VIA1_C_CDNS_70 $T=142100 164185 0 0 $X=141960 $Y=163475
X274 19 VIA1_C_CDNS_70 $T=144140 47040 0 0 $X=144000 $Y=46330
X275 18 VIA1_C_CDNS_70 $T=144580 164185 0 0 $X=144440 $Y=163475
X276 3 VIA1_C_CDNS_70 $T=145410 124960 0 0 $X=145270 $Y=124250
X277 20 VIA1_C_CDNS_70 $T=145850 220885 0 0 $X=145710 $Y=220175
X278 18 VIA1_C_CDNS_70 $T=146680 48820 0 0 $X=146540 $Y=48110
X279 2 VIA1_C_CDNS_70 $T=147120 153505 0 0 $X=146980 $Y=152795
X280 19 VIA1_C_CDNS_70 $T=149160 47040 0 0 $X=149020 $Y=46330
X281 18 VIA1_C_CDNS_70 $T=149600 164185 0 0 $X=149460 $Y=163475
X282 3 VIA1_C_CDNS_70 $T=150430 124960 0 0 $X=150290 $Y=124250
X283 20 VIA1_C_CDNS_70 $T=150870 220885 0 0 $X=150730 $Y=220175
X284 18 VIA1_C_CDNS_70 $T=151700 48820 0 0 $X=151560 $Y=48110
X285 2 VIA1_C_CDNS_70 $T=152140 153505 0 0 $X=152000 $Y=152795
X286 19 VIA1_C_CDNS_70 $T=154180 47040 0 0 $X=154040 $Y=46330
X287 18 VIA1_C_CDNS_70 $T=154620 164185 0 0 $X=154480 $Y=163475
X288 3 VIA1_C_CDNS_70 $T=155450 124960 0 0 $X=155310 $Y=124250
X289 20 VIA1_C_CDNS_70 $T=155890 220885 0 0 $X=155750 $Y=220175
X290 18 VIA1_C_CDNS_70 $T=156720 48820 0 0 $X=156580 $Y=48110
X291 2 VIA1_C_CDNS_70 $T=157160 153505 0 0 $X=157020 $Y=152795
X292 19 VIA1_C_CDNS_70 $T=159200 47040 0 0 $X=159060 $Y=46330
X293 18 VIA1_C_CDNS_70 $T=159640 164185 0 0 $X=159500 $Y=163475
X294 3 VIA1_C_CDNS_70 $T=160470 124960 0 0 $X=160330 $Y=124250
X295 20 VIA1_C_CDNS_70 $T=160910 220885 0 0 $X=160770 $Y=220175
X296 18 VIA1_C_CDNS_70 $T=161740 48820 0 0 $X=161600 $Y=48110
X297 2 VIA1_C_CDNS_70 $T=162180 153505 0 0 $X=162040 $Y=152795
X298 19 VIA1_C_CDNS_70 $T=164220 47040 0 0 $X=164080 $Y=46330
X299 18 VIA1_C_CDNS_70 $T=164660 164185 0 0 $X=164520 $Y=163475
X300 3 VIA1_C_CDNS_70 $T=165490 124960 0 0 $X=165350 $Y=124250
X301 20 VIA1_C_CDNS_70 $T=165930 220885 0 0 $X=165790 $Y=220175
X302 18 VIA1_C_CDNS_70 $T=166760 48820 0 0 $X=166620 $Y=48110
X303 2 VIA1_C_CDNS_70 $T=167200 153505 0 0 $X=167060 $Y=152795
X304 19 VIA1_C_CDNS_70 $T=169240 47040 0 0 $X=169100 $Y=46330
X305 18 VIA1_C_CDNS_70 $T=169680 164185 0 0 $X=169540 $Y=163475
X306 3 VIA1_C_CDNS_70 $T=170510 124960 0 0 $X=170370 $Y=124250
X307 20 VIA1_C_CDNS_70 $T=170950 220885 0 0 $X=170810 $Y=220175
X308 18 VIA1_C_CDNS_70 $T=171780 48820 0 0 $X=171640 $Y=48110
X309 2 VIA1_C_CDNS_70 $T=172220 153505 0 0 $X=172080 $Y=152795
X310 19 VIA1_C_CDNS_70 $T=174260 47040 0 0 $X=174120 $Y=46330
X311 18 VIA1_C_CDNS_70 $T=174700 164185 0 0 $X=174560 $Y=163475
X312 3 VIA1_C_CDNS_70 $T=175530 124960 0 0 $X=175390 $Y=124250
X313 20 VIA1_C_CDNS_70 $T=175970 220885 0 0 $X=175830 $Y=220175
X314 18 VIA1_C_CDNS_70 $T=176800 48820 0 0 $X=176660 $Y=48110
X315 2 VIA1_C_CDNS_70 $T=177240 153505 0 0 $X=177100 $Y=152795
X316 2 VIA1_C_CDNS_70 $T=179720 153505 0 0 $X=179580 $Y=152795
X317 2 VIA1_C_CDNS_70 $T=180990 231565 0 0 $X=180850 $Y=230855
X318 2 VIA1_C_CDNS_70 $T=182260 153505 0 0 $X=182120 $Y=152795
X319 2 VIA1_C_CDNS_71 $T=14060 174755 0 0 $X=13870 $Y=174355
X320 2 VIA1_C_CDNS_71 $T=14060 190375 0 0 $X=13870 $Y=189975
X321 2 VIA1_C_CDNS_71 $T=14060 205995 0 0 $X=13870 $Y=205595
X322 2 VIA1_C_CDNS_71 $T=15330 174755 0 0 $X=15140 $Y=174355
X323 2 VIA1_C_CDNS_71 $T=15330 190375 0 0 $X=15140 $Y=189975
X324 2 VIA1_C_CDNS_71 $T=15330 205995 0 0 $X=15140 $Y=205595
X325 2 VIA1_C_CDNS_71 $T=16600 174755 0 0 $X=16410 $Y=174355
X326 2 VIA1_C_CDNS_71 $T=16600 190375 0 0 $X=16410 $Y=189975
X327 2 VIA1_C_CDNS_71 $T=16600 205995 0 0 $X=16410 $Y=205595
X328 16 VIA1_C_CDNS_71 $T=18640 69110 0 0 $X=18450 $Y=68710
X329 16 VIA1_C_CDNS_71 $T=18640 91210 0 0 $X=18450 $Y=90810
X330 18 VIA1_C_CDNS_71 $T=18640 115470 0 0 $X=18450 $Y=115070
X331 2 VIA1_C_CDNS_71 $T=19080 174755 0 0 $X=18890 $Y=174355
X332 2 VIA1_C_CDNS_71 $T=19080 190375 0 0 $X=18890 $Y=189975
X333 2 VIA1_C_CDNS_71 $T=19080 205995 0 0 $X=18890 $Y=205595
X334 3 VIA1_C_CDNS_71 $T=19910 58310 0 0 $X=19720 $Y=57910
X335 3 VIA1_C_CDNS_71 $T=19910 80410 0 0 $X=19720 $Y=80010
X336 3 VIA1_C_CDNS_71 $T=19910 102510 0 0 $X=19720 $Y=102110
X337 20 VIA1_C_CDNS_71 $T=20350 173675 0 0 $X=20160 $Y=173275
X338 20 VIA1_C_CDNS_71 $T=20350 189295 0 0 $X=20160 $Y=188895
X339 20 VIA1_C_CDNS_71 $T=20350 204915 0 0 $X=20160 $Y=204515
X340 17 VIA1_C_CDNS_71 $T=21180 68030 0 0 $X=20990 $Y=67630
X341 17 VIA1_C_CDNS_71 $T=21180 90130 0 0 $X=20990 $Y=89730
X342 19 VIA1_C_CDNS_71 $T=21180 114390 0 0 $X=20990 $Y=113990
X343 16 VIA1_C_CDNS_71 $T=21620 179075 0 0 $X=21430 $Y=178675
X344 16 VIA1_C_CDNS_71 $T=21620 194695 0 0 $X=21430 $Y=194295
X345 18 VIA1_C_CDNS_71 $T=21620 211395 0 0 $X=21430 $Y=210995
X346 18 VIA1_C_CDNS_71 $T=23660 71270 0 0 $X=23470 $Y=70870
X347 18 VIA1_C_CDNS_71 $T=23660 93370 0 0 $X=23470 $Y=92970
X348 18 VIA1_C_CDNS_71 $T=23660 115470 0 0 $X=23470 $Y=115070
X349 2 VIA1_C_CDNS_71 $T=24100 174755 0 0 $X=23910 $Y=174355
X350 2 VIA1_C_CDNS_71 $T=24100 190375 0 0 $X=23910 $Y=189975
X351 2 VIA1_C_CDNS_71 $T=24100 205995 0 0 $X=23910 $Y=205595
X352 3 VIA1_C_CDNS_71 $T=24930 58310 0 0 $X=24740 $Y=57910
X353 3 VIA1_C_CDNS_71 $T=24930 80410 0 0 $X=24740 $Y=80010
X354 3 VIA1_C_CDNS_71 $T=24930 102510 0 0 $X=24740 $Y=102110
X355 20 VIA1_C_CDNS_71 $T=25370 173675 0 0 $X=25180 $Y=173275
X356 20 VIA1_C_CDNS_71 $T=25370 189295 0 0 $X=25180 $Y=188895
X357 20 VIA1_C_CDNS_71 $T=25370 204915 0 0 $X=25180 $Y=204515
X358 19 VIA1_C_CDNS_71 $T=26200 70190 0 0 $X=26010 $Y=69790
X359 19 VIA1_C_CDNS_71 $T=26200 92290 0 0 $X=26010 $Y=91890
X360 19 VIA1_C_CDNS_71 $T=26200 114390 0 0 $X=26010 $Y=113990
X361 18 VIA1_C_CDNS_71 $T=26640 180155 0 0 $X=26450 $Y=179755
X362 18 VIA1_C_CDNS_71 $T=26640 195775 0 0 $X=26450 $Y=195375
X363 18 VIA1_C_CDNS_71 $T=26640 211395 0 0 $X=26450 $Y=210995
X364 16 VIA1_C_CDNS_71 $T=28680 69110 0 0 $X=28490 $Y=68710
X365 16 VIA1_C_CDNS_71 $T=28680 91210 0 0 $X=28490 $Y=90810
X366 18 VIA1_C_CDNS_71 $T=28680 115470 0 0 $X=28490 $Y=115070
X367 2 VIA1_C_CDNS_71 $T=29120 174755 0 0 $X=28930 $Y=174355
X368 2 VIA1_C_CDNS_71 $T=29120 190375 0 0 $X=28930 $Y=189975
X369 2 VIA1_C_CDNS_71 $T=29120 205995 0 0 $X=28930 $Y=205595
X370 3 VIA1_C_CDNS_71 $T=29950 58310 0 0 $X=29760 $Y=57910
X371 3 VIA1_C_CDNS_71 $T=29950 80410 0 0 $X=29760 $Y=80010
X372 3 VIA1_C_CDNS_71 $T=29950 102510 0 0 $X=29760 $Y=102110
X373 20 VIA1_C_CDNS_71 $T=30390 173675 0 0 $X=30200 $Y=173275
X374 20 VIA1_C_CDNS_71 $T=30390 189295 0 0 $X=30200 $Y=188895
X375 20 VIA1_C_CDNS_71 $T=30390 204915 0 0 $X=30200 $Y=204515
X376 17 VIA1_C_CDNS_71 $T=31220 68030 0 0 $X=31030 $Y=67630
X377 17 VIA1_C_CDNS_71 $T=31220 90130 0 0 $X=31030 $Y=89730
X378 19 VIA1_C_CDNS_71 $T=31220 114390 0 0 $X=31030 $Y=113990
X379 16 VIA1_C_CDNS_71 $T=31660 179075 0 0 $X=31470 $Y=178675
X380 16 VIA1_C_CDNS_71 $T=31660 194695 0 0 $X=31470 $Y=194295
X381 18 VIA1_C_CDNS_71 $T=31660 211395 0 0 $X=31470 $Y=210995
X382 18 VIA1_C_CDNS_71 $T=33700 71270 0 0 $X=33510 $Y=70870
X383 18 VIA1_C_CDNS_71 $T=33700 93370 0 0 $X=33510 $Y=92970
X384 18 VIA1_C_CDNS_71 $T=33700 115470 0 0 $X=33510 $Y=115070
X385 2 VIA1_C_CDNS_71 $T=34140 174755 0 0 $X=33950 $Y=174355
X386 2 VIA1_C_CDNS_71 $T=34140 190375 0 0 $X=33950 $Y=189975
X387 2 VIA1_C_CDNS_71 $T=34140 205995 0 0 $X=33950 $Y=205595
X388 3 VIA1_C_CDNS_71 $T=34970 58310 0 0 $X=34780 $Y=57910
X389 3 VIA1_C_CDNS_71 $T=34970 80410 0 0 $X=34780 $Y=80010
X390 3 VIA1_C_CDNS_71 $T=34970 102510 0 0 $X=34780 $Y=102110
X391 20 VIA1_C_CDNS_71 $T=35410 173675 0 0 $X=35220 $Y=173275
X392 20 VIA1_C_CDNS_71 $T=35410 189295 0 0 $X=35220 $Y=188895
X393 20 VIA1_C_CDNS_71 $T=35410 204915 0 0 $X=35220 $Y=204515
X394 19 VIA1_C_CDNS_71 $T=36240 70190 0 0 $X=36050 $Y=69790
X395 19 VIA1_C_CDNS_71 $T=36240 92290 0 0 $X=36050 $Y=91890
X396 19 VIA1_C_CDNS_71 $T=36240 114390 0 0 $X=36050 $Y=113990
X397 18 VIA1_C_CDNS_71 $T=36680 180155 0 0 $X=36490 $Y=179755
X398 18 VIA1_C_CDNS_71 $T=36680 195775 0 0 $X=36490 $Y=195375
X399 18 VIA1_C_CDNS_71 $T=36680 211395 0 0 $X=36490 $Y=210995
X400 16 VIA1_C_CDNS_71 $T=38720 69110 0 0 $X=38530 $Y=68710
X401 16 VIA1_C_CDNS_71 $T=38720 91210 0 0 $X=38530 $Y=90810
X402 18 VIA1_C_CDNS_71 $T=38720 115470 0 0 $X=38530 $Y=115070
X403 2 VIA1_C_CDNS_71 $T=39160 174755 0 0 $X=38970 $Y=174355
X404 2 VIA1_C_CDNS_71 $T=39160 190375 0 0 $X=38970 $Y=189975
X405 2 VIA1_C_CDNS_71 $T=39160 205995 0 0 $X=38970 $Y=205595
X406 3 VIA1_C_CDNS_71 $T=39990 58310 0 0 $X=39800 $Y=57910
X407 3 VIA1_C_CDNS_71 $T=39990 80410 0 0 $X=39800 $Y=80010
X408 3 VIA1_C_CDNS_71 $T=39990 102510 0 0 $X=39800 $Y=102110
X409 20 VIA1_C_CDNS_71 $T=40430 173675 0 0 $X=40240 $Y=173275
X410 20 VIA1_C_CDNS_71 $T=40430 189295 0 0 $X=40240 $Y=188895
X411 20 VIA1_C_CDNS_71 $T=40430 204915 0 0 $X=40240 $Y=204515
X412 17 VIA1_C_CDNS_71 $T=41260 68030 0 0 $X=41070 $Y=67630
X413 17 VIA1_C_CDNS_71 $T=41260 90130 0 0 $X=41070 $Y=89730
X414 19 VIA1_C_CDNS_71 $T=41260 114390 0 0 $X=41070 $Y=113990
X415 16 VIA1_C_CDNS_71 $T=41700 179075 0 0 $X=41510 $Y=178675
X416 16 VIA1_C_CDNS_71 $T=41700 194695 0 0 $X=41510 $Y=194295
X417 18 VIA1_C_CDNS_71 $T=41700 211395 0 0 $X=41510 $Y=210995
X418 18 VIA1_C_CDNS_71 $T=43740 71270 0 0 $X=43550 $Y=70870
X419 18 VIA1_C_CDNS_71 $T=43740 93370 0 0 $X=43550 $Y=92970
X420 18 VIA1_C_CDNS_71 $T=43740 115470 0 0 $X=43550 $Y=115070
X421 2 VIA1_C_CDNS_71 $T=44180 174755 0 0 $X=43990 $Y=174355
X422 2 VIA1_C_CDNS_71 $T=44180 190375 0 0 $X=43990 $Y=189975
X423 2 VIA1_C_CDNS_71 $T=44180 205995 0 0 $X=43990 $Y=205595
X424 3 VIA1_C_CDNS_71 $T=45010 58310 0 0 $X=44820 $Y=57910
X425 3 VIA1_C_CDNS_71 $T=45010 80410 0 0 $X=44820 $Y=80010
X426 3 VIA1_C_CDNS_71 $T=45010 102510 0 0 $X=44820 $Y=102110
X427 20 VIA1_C_CDNS_71 $T=45450 173675 0 0 $X=45260 $Y=173275
X428 20 VIA1_C_CDNS_71 $T=45450 189295 0 0 $X=45260 $Y=188895
X429 20 VIA1_C_CDNS_71 $T=45450 204915 0 0 $X=45260 $Y=204515
X430 19 VIA1_C_CDNS_71 $T=46280 70190 0 0 $X=46090 $Y=69790
X431 19 VIA1_C_CDNS_71 $T=46280 92290 0 0 $X=46090 $Y=91890
X432 19 VIA1_C_CDNS_71 $T=46280 114390 0 0 $X=46090 $Y=113990
X433 18 VIA1_C_CDNS_71 $T=46720 180155 0 0 $X=46530 $Y=179755
X434 18 VIA1_C_CDNS_71 $T=46720 195775 0 0 $X=46530 $Y=195375
X435 18 VIA1_C_CDNS_71 $T=46720 211395 0 0 $X=46530 $Y=210995
X436 16 VIA1_C_CDNS_71 $T=48760 69110 0 0 $X=48570 $Y=68710
X437 16 VIA1_C_CDNS_71 $T=48760 91210 0 0 $X=48570 $Y=90810
X438 18 VIA1_C_CDNS_71 $T=48760 115470 0 0 $X=48570 $Y=115070
X439 2 VIA1_C_CDNS_71 $T=49200 174755 0 0 $X=49010 $Y=174355
X440 2 VIA1_C_CDNS_71 $T=49200 190375 0 0 $X=49010 $Y=189975
X441 2 VIA1_C_CDNS_71 $T=49200 205995 0 0 $X=49010 $Y=205595
X442 3 VIA1_C_CDNS_71 $T=50030 58310 0 0 $X=49840 $Y=57910
X443 3 VIA1_C_CDNS_71 $T=50030 80410 0 0 $X=49840 $Y=80010
X444 3 VIA1_C_CDNS_71 $T=50030 102510 0 0 $X=49840 $Y=102110
X445 20 VIA1_C_CDNS_71 $T=50470 173675 0 0 $X=50280 $Y=173275
X446 20 VIA1_C_CDNS_71 $T=50470 189295 0 0 $X=50280 $Y=188895
X447 20 VIA1_C_CDNS_71 $T=50470 204915 0 0 $X=50280 $Y=204515
X448 17 VIA1_C_CDNS_71 $T=51300 68030 0 0 $X=51110 $Y=67630
X449 17 VIA1_C_CDNS_71 $T=51300 90130 0 0 $X=51110 $Y=89730
X450 19 VIA1_C_CDNS_71 $T=51300 114390 0 0 $X=51110 $Y=113990
X451 16 VIA1_C_CDNS_71 $T=51740 179075 0 0 $X=51550 $Y=178675
X452 16 VIA1_C_CDNS_71 $T=51740 194695 0 0 $X=51550 $Y=194295
X453 18 VIA1_C_CDNS_71 $T=51740 211395 0 0 $X=51550 $Y=210995
X454 14 VIA1_C_CDNS_71 $T=53780 66950 0 0 $X=53590 $Y=66550
X455 14 VIA1_C_CDNS_71 $T=53780 89050 0 0 $X=53590 $Y=88650
X456 18 VIA1_C_CDNS_71 $T=53780 115470 0 0 $X=53590 $Y=115070
X457 2 VIA1_C_CDNS_71 $T=54220 174755 0 0 $X=54030 $Y=174355
X458 2 VIA1_C_CDNS_71 $T=54220 190375 0 0 $X=54030 $Y=189975
X459 2 VIA1_C_CDNS_71 $T=54220 205995 0 0 $X=54030 $Y=205595
X460 3 VIA1_C_CDNS_71 $T=55050 58310 0 0 $X=54860 $Y=57910
X461 3 VIA1_C_CDNS_71 $T=55050 80410 0 0 $X=54860 $Y=80010
X462 3 VIA1_C_CDNS_71 $T=55050 102510 0 0 $X=54860 $Y=102110
X463 20 VIA1_C_CDNS_71 $T=55490 173675 0 0 $X=55300 $Y=173275
X464 20 VIA1_C_CDNS_71 $T=55490 189295 0 0 $X=55300 $Y=188895
X465 20 VIA1_C_CDNS_71 $T=55490 204915 0 0 $X=55300 $Y=204515
X466 15 VIA1_C_CDNS_71 $T=56320 65870 0 0 $X=56130 $Y=65470
X467 15 VIA1_C_CDNS_71 $T=56320 87970 0 0 $X=56130 $Y=87570
X468 19 VIA1_C_CDNS_71 $T=56320 114390 0 0 $X=56130 $Y=113990
X469 14 VIA1_C_CDNS_71 $T=56760 177995 0 0 $X=56570 $Y=177595
X470 14 VIA1_C_CDNS_71 $T=56760 193615 0 0 $X=56570 $Y=193215
X471 18 VIA1_C_CDNS_71 $T=56760 211395 0 0 $X=56570 $Y=210995
X472 16 VIA1_C_CDNS_71 $T=58800 69110 0 0 $X=58610 $Y=68710
X473 16 VIA1_C_CDNS_71 $T=58800 91210 0 0 $X=58610 $Y=90810
X474 18 VIA1_C_CDNS_71 $T=58800 115470 0 0 $X=58610 $Y=115070
X475 2 VIA1_C_CDNS_71 $T=59240 174755 0 0 $X=59050 $Y=174355
X476 2 VIA1_C_CDNS_71 $T=59240 190375 0 0 $X=59050 $Y=189975
X477 2 VIA1_C_CDNS_71 $T=59240 205995 0 0 $X=59050 $Y=205595
X478 3 VIA1_C_CDNS_71 $T=60070 58310 0 0 $X=59880 $Y=57910
X479 3 VIA1_C_CDNS_71 $T=60070 80410 0 0 $X=59880 $Y=80010
X480 3 VIA1_C_CDNS_71 $T=60070 102510 0 0 $X=59880 $Y=102110
X481 20 VIA1_C_CDNS_71 $T=60510 189295 0 0 $X=60320 $Y=188895
X482 20 VIA1_C_CDNS_71 $T=60510 204915 0 0 $X=60320 $Y=204515
X483 17 VIA1_C_CDNS_71 $T=61340 68030 0 0 $X=61150 $Y=67630
X484 17 VIA1_C_CDNS_71 $T=61340 90130 0 0 $X=61150 $Y=89730
X485 19 VIA1_C_CDNS_71 $T=61340 114390 0 0 $X=61150 $Y=113990
X486 16 VIA1_C_CDNS_71 $T=61780 179075 0 0 $X=61590 $Y=178675
X487 16 VIA1_C_CDNS_71 $T=61780 194695 0 0 $X=61590 $Y=194295
X488 18 VIA1_C_CDNS_71 $T=61780 211395 0 0 $X=61590 $Y=210995
X489 14 VIA1_C_CDNS_71 $T=63820 66950 0 0 $X=63630 $Y=66550
X490 14 VIA1_C_CDNS_71 $T=63820 89050 0 0 $X=63630 $Y=88650
X491 18 VIA1_C_CDNS_71 $T=63820 115470 0 0 $X=63630 $Y=115070
X492 2 VIA1_C_CDNS_71 $T=64260 174755 0 0 $X=64070 $Y=174355
X493 2 VIA1_C_CDNS_71 $T=64260 190375 0 0 $X=64070 $Y=189975
X494 2 VIA1_C_CDNS_71 $T=64260 205995 0 0 $X=64070 $Y=205595
X495 3 VIA1_C_CDNS_71 $T=65090 58310 0 0 $X=64900 $Y=57910
X496 3 VIA1_C_CDNS_71 $T=65090 80410 0 0 $X=64900 $Y=80010
X497 3 VIA1_C_CDNS_71 $T=65090 102510 0 0 $X=64900 $Y=102110
X498 20 VIA1_C_CDNS_71 $T=65530 173675 0 0 $X=65340 $Y=173275
X499 20 VIA1_C_CDNS_71 $T=65530 189295 0 0 $X=65340 $Y=188895
X500 20 VIA1_C_CDNS_71 $T=65530 204915 0 0 $X=65340 $Y=204515
X501 15 VIA1_C_CDNS_71 $T=66360 65870 0 0 $X=66170 $Y=65470
X502 15 VIA1_C_CDNS_71 $T=66360 87970 0 0 $X=66170 $Y=87570
X503 19 VIA1_C_CDNS_71 $T=66360 114390 0 0 $X=66170 $Y=113990
X504 14 VIA1_C_CDNS_71 $T=66800 177995 0 0 $X=66610 $Y=177595
X505 14 VIA1_C_CDNS_71 $T=66800 193615 0 0 $X=66610 $Y=193215
X506 18 VIA1_C_CDNS_71 $T=66800 211395 0 0 $X=66610 $Y=210995
X507 16 VIA1_C_CDNS_71 $T=68840 69110 0 0 $X=68650 $Y=68710
X508 16 VIA1_C_CDNS_71 $T=68840 91210 0 0 $X=68650 $Y=90810
X509 18 VIA1_C_CDNS_71 $T=68840 115470 0 0 $X=68650 $Y=115070
X510 2 VIA1_C_CDNS_71 $T=69280 174755 0 0 $X=69090 $Y=174355
X511 2 VIA1_C_CDNS_71 $T=69280 190375 0 0 $X=69090 $Y=189975
X512 2 VIA1_C_CDNS_71 $T=69280 205995 0 0 $X=69090 $Y=205595
X513 3 VIA1_C_CDNS_71 $T=70110 58310 0 0 $X=69920 $Y=57910
X514 3 VIA1_C_CDNS_71 $T=70110 80410 0 0 $X=69920 $Y=80010
X515 3 VIA1_C_CDNS_71 $T=70110 102510 0 0 $X=69920 $Y=102110
X516 20 VIA1_C_CDNS_71 $T=70550 173675 0 0 $X=70360 $Y=173275
X517 20 VIA1_C_CDNS_71 $T=70550 189295 0 0 $X=70360 $Y=188895
X518 20 VIA1_C_CDNS_71 $T=70550 204915 0 0 $X=70360 $Y=204515
X519 17 VIA1_C_CDNS_71 $T=71380 68030 0 0 $X=71190 $Y=67630
X520 17 VIA1_C_CDNS_71 $T=71380 90130 0 0 $X=71190 $Y=89730
X521 19 VIA1_C_CDNS_71 $T=71380 114390 0 0 $X=71190 $Y=113990
X522 16 VIA1_C_CDNS_71 $T=71820 179075 0 0 $X=71630 $Y=178675
X523 16 VIA1_C_CDNS_71 $T=71820 194695 0 0 $X=71630 $Y=194295
X524 18 VIA1_C_CDNS_71 $T=71820 211395 0 0 $X=71630 $Y=210995
X525 14 VIA1_C_CDNS_71 $T=73860 66950 0 0 $X=73670 $Y=66550
X526 14 VIA1_C_CDNS_71 $T=73860 89050 0 0 $X=73670 $Y=88650
X527 18 VIA1_C_CDNS_71 $T=73860 115470 0 0 $X=73670 $Y=115070
X528 2 VIA1_C_CDNS_71 $T=74300 174755 0 0 $X=74110 $Y=174355
X529 2 VIA1_C_CDNS_71 $T=74300 190375 0 0 $X=74110 $Y=189975
X530 2 VIA1_C_CDNS_71 $T=74300 205995 0 0 $X=74110 $Y=205595
X531 3 VIA1_C_CDNS_71 $T=75130 58310 0 0 $X=74940 $Y=57910
X532 3 VIA1_C_CDNS_71 $T=75130 80410 0 0 $X=74940 $Y=80010
X533 3 VIA1_C_CDNS_71 $T=75130 102510 0 0 $X=74940 $Y=102110
X534 20 VIA1_C_CDNS_71 $T=75570 173675 0 0 $X=75380 $Y=173275
X535 20 VIA1_C_CDNS_71 $T=75570 189295 0 0 $X=75380 $Y=188895
X536 20 VIA1_C_CDNS_71 $T=75570 204915 0 0 $X=75380 $Y=204515
X537 15 VIA1_C_CDNS_71 $T=76400 65870 0 0 $X=76210 $Y=65470
X538 15 VIA1_C_CDNS_71 $T=76400 87970 0 0 $X=76210 $Y=87570
X539 19 VIA1_C_CDNS_71 $T=76400 114390 0 0 $X=76210 $Y=113990
X540 14 VIA1_C_CDNS_71 $T=76840 177995 0 0 $X=76650 $Y=177595
X541 14 VIA1_C_CDNS_71 $T=76840 193615 0 0 $X=76650 $Y=193215
X542 18 VIA1_C_CDNS_71 $T=76840 211395 0 0 $X=76650 $Y=210995
X543 16 VIA1_C_CDNS_71 $T=78880 69110 0 0 $X=78690 $Y=68710
X544 16 VIA1_C_CDNS_71 $T=78880 91210 0 0 $X=78690 $Y=90810
X545 18 VIA1_C_CDNS_71 $T=78880 115470 0 0 $X=78690 $Y=115070
X546 2 VIA1_C_CDNS_71 $T=79320 174755 0 0 $X=79130 $Y=174355
X547 2 VIA1_C_CDNS_71 $T=79320 190375 0 0 $X=79130 $Y=189975
X548 2 VIA1_C_CDNS_71 $T=79320 205995 0 0 $X=79130 $Y=205595
X549 3 VIA1_C_CDNS_71 $T=80150 58310 0 0 $X=79960 $Y=57910
X550 3 VIA1_C_CDNS_71 $T=80150 80410 0 0 $X=79960 $Y=80010
X551 3 VIA1_C_CDNS_71 $T=80150 102510 0 0 $X=79960 $Y=102110
X552 20 VIA1_C_CDNS_71 $T=80590 173675 0 0 $X=80400 $Y=173275
X553 20 VIA1_C_CDNS_71 $T=80590 189295 0 0 $X=80400 $Y=188895
X554 20 VIA1_C_CDNS_71 $T=80590 204915 0 0 $X=80400 $Y=204515
X555 17 VIA1_C_CDNS_71 $T=81420 68030 0 0 $X=81230 $Y=67630
X556 17 VIA1_C_CDNS_71 $T=81420 90130 0 0 $X=81230 $Y=89730
X557 19 VIA1_C_CDNS_71 $T=81420 114390 0 0 $X=81230 $Y=113990
X558 16 VIA1_C_CDNS_71 $T=81860 179075 0 0 $X=81670 $Y=178675
X559 16 VIA1_C_CDNS_71 $T=81860 194695 0 0 $X=81670 $Y=194295
X560 18 VIA1_C_CDNS_71 $T=81860 211395 0 0 $X=81670 $Y=210995
X561 14 VIA1_C_CDNS_71 $T=83900 66950 0 0 $X=83710 $Y=66550
X562 14 VIA1_C_CDNS_71 $T=83900 89050 0 0 $X=83710 $Y=88650
X563 16 VIA1_C_CDNS_71 $T=83900 113310 0 0 $X=83710 $Y=112910
X564 2 VIA1_C_CDNS_71 $T=84340 174755 0 0 $X=84150 $Y=174355
X565 2 VIA1_C_CDNS_71 $T=84340 190375 0 0 $X=84150 $Y=189975
X566 2 VIA1_C_CDNS_71 $T=84340 205995 0 0 $X=84150 $Y=205595
X567 3 VIA1_C_CDNS_71 $T=85170 58310 0 0 $X=84980 $Y=57910
X568 3 VIA1_C_CDNS_71 $T=85170 80410 0 0 $X=84980 $Y=80010
X569 3 VIA1_C_CDNS_71 $T=85170 102510 0 0 $X=84980 $Y=102110
X570 20 VIA1_C_CDNS_71 $T=85610 173675 0 0 $X=85420 $Y=173275
X571 20 VIA1_C_CDNS_71 $T=85610 189295 0 0 $X=85420 $Y=188895
X572 20 VIA1_C_CDNS_71 $T=85610 204915 0 0 $X=85420 $Y=204515
X573 15 VIA1_C_CDNS_71 $T=86440 65870 0 0 $X=86250 $Y=65470
X574 15 VIA1_C_CDNS_71 $T=86440 87970 0 0 $X=86250 $Y=87570
X575 17 VIA1_C_CDNS_71 $T=86440 112230 0 0 $X=86250 $Y=111830
X576 14 VIA1_C_CDNS_71 $T=86880 177995 0 0 $X=86690 $Y=177595
X577 14 VIA1_C_CDNS_71 $T=86880 193615 0 0 $X=86690 $Y=193215
X578 16 VIA1_C_CDNS_71 $T=86880 210315 0 0 $X=86690 $Y=209915
X579 12 VIA1_C_CDNS_71 $T=88920 64790 0 0 $X=88730 $Y=64390
X580 12 VIA1_C_CDNS_71 $T=88920 86890 0 0 $X=88730 $Y=86490
X581 10 VIA1_C_CDNS_71 $T=88920 106830 0 0 $X=88730 $Y=106430
X582 2 VIA1_C_CDNS_71 $T=89360 174755 0 0 $X=89170 $Y=174355
X583 2 VIA1_C_CDNS_71 $T=89360 190375 0 0 $X=89170 $Y=189975
X584 2 VIA1_C_CDNS_71 $T=89360 205995 0 0 $X=89170 $Y=205595
X585 3 VIA1_C_CDNS_71 $T=90190 58310 0 0 $X=90000 $Y=57910
X586 3 VIA1_C_CDNS_71 $T=90190 80410 0 0 $X=90000 $Y=80010
X587 3 VIA1_C_CDNS_71 $T=90190 102510 0 0 $X=90000 $Y=102110
X588 20 VIA1_C_CDNS_71 $T=90630 173675 0 0 $X=90440 $Y=173275
X589 20 VIA1_C_CDNS_71 $T=90630 189295 0 0 $X=90440 $Y=188895
X590 20 VIA1_C_CDNS_71 $T=90630 204915 0 0 $X=90440 $Y=204515
X591 13 VIA1_C_CDNS_71 $T=91460 63710 0 0 $X=91270 $Y=63310
X592 13 VIA1_C_CDNS_71 $T=91460 85810 0 0 $X=91270 $Y=85410
X593 11 VIA1_C_CDNS_71 $T=91460 105750 0 0 $X=91270 $Y=105350
X594 12 VIA1_C_CDNS_71 $T=91900 176915 0 0 $X=91710 $Y=176515
X595 12 VIA1_C_CDNS_71 $T=91900 192535 0 0 $X=91710 $Y=192135
X596 10 VIA1_C_CDNS_71 $T=91900 207075 0 0 $X=91710 $Y=206675
X597 20 VIA1_C_CDNS_71 $T=93940 60470 0 0 $X=93750 $Y=60070
X598 20 VIA1_C_CDNS_71 $T=93940 82570 0 0 $X=93750 $Y=82170
X599 12 VIA1_C_CDNS_71 $T=93940 108990 0 0 $X=93750 $Y=108590
X600 2 VIA1_C_CDNS_71 $T=94380 174755 0 0 $X=94190 $Y=174355
X601 2 VIA1_C_CDNS_71 $T=94380 190375 0 0 $X=94190 $Y=189975
X602 2 VIA1_C_CDNS_71 $T=94380 205995 0 0 $X=94190 $Y=205595
X603 3 VIA1_C_CDNS_71 $T=95210 58310 0 0 $X=95020 $Y=57910
X604 3 VIA1_C_CDNS_71 $T=95210 80410 0 0 $X=95020 $Y=80010
X605 3 VIA1_C_CDNS_71 $T=95210 102510 0 0 $X=95020 $Y=102110
X606 20 VIA1_C_CDNS_71 $T=95650 173675 0 0 $X=95460 $Y=173275
X607 20 VIA1_C_CDNS_71 $T=95650 189295 0 0 $X=95460 $Y=188895
X608 20 VIA1_C_CDNS_71 $T=95650 204915 0 0 $X=95460 $Y=204515
X609 3 VIA1_C_CDNS_71 $T=96480 58310 0 0 $X=96290 $Y=57910
X610 3 VIA1_C_CDNS_71 $T=96480 80410 0 0 $X=96290 $Y=80010
X611 13 VIA1_C_CDNS_71 $T=96480 107910 0 0 $X=96290 $Y=107510
X612 20 VIA1_C_CDNS_71 $T=96920 173675 0 0 $X=96730 $Y=173275
X613 20 VIA1_C_CDNS_71 $T=96920 189295 0 0 $X=96730 $Y=188895
X614 12 VIA1_C_CDNS_71 $T=96920 208155 0 0 $X=96730 $Y=207755
X615 20 VIA1_C_CDNS_71 $T=98960 60470 0 0 $X=98770 $Y=60070
X616 20 VIA1_C_CDNS_71 $T=98960 82570 0 0 $X=98770 $Y=82170
X617 12 VIA1_C_CDNS_71 $T=98960 108990 0 0 $X=98770 $Y=108590
X618 2 VIA1_C_CDNS_71 $T=99400 174755 0 0 $X=99210 $Y=174355
X619 2 VIA1_C_CDNS_71 $T=99400 190375 0 0 $X=99210 $Y=189975
X620 2 VIA1_C_CDNS_71 $T=99400 205995 0 0 $X=99210 $Y=205595
X621 3 VIA1_C_CDNS_71 $T=100230 80410 0 0 $X=100040 $Y=80010
X622 3 VIA1_C_CDNS_71 $T=100230 102510 0 0 $X=100040 $Y=102110
X623 20 VIA1_C_CDNS_71 $T=100670 173675 0 0 $X=100480 $Y=173275
X624 20 VIA1_C_CDNS_71 $T=100670 189295 0 0 $X=100480 $Y=188895
X625 20 VIA1_C_CDNS_71 $T=100670 204915 0 0 $X=100480 $Y=204515
X626 3 VIA1_C_CDNS_71 $T=101500 58310 0 0 $X=101310 $Y=57910
X627 3 VIA1_C_CDNS_71 $T=101500 80410 0 0 $X=101310 $Y=80010
X628 13 VIA1_C_CDNS_71 $T=101500 107910 0 0 $X=101310 $Y=107510
X629 20 VIA1_C_CDNS_71 $T=101940 173675 0 0 $X=101750 $Y=173275
X630 20 VIA1_C_CDNS_71 $T=101940 189295 0 0 $X=101750 $Y=188895
X631 12 VIA1_C_CDNS_71 $T=101940 208155 0 0 $X=101750 $Y=207755
X632 13 VIA1_C_CDNS_71 $T=103980 63710 0 0 $X=103790 $Y=63310
X633 13 VIA1_C_CDNS_71 $T=103980 85810 0 0 $X=103790 $Y=85410
X634 11 VIA1_C_CDNS_71 $T=103980 105750 0 0 $X=103790 $Y=105350
X635 12 VIA1_C_CDNS_71 $T=104420 176915 0 0 $X=104230 $Y=176515
X636 12 VIA1_C_CDNS_71 $T=104420 192535 0 0 $X=104230 $Y=192135
X637 10 VIA1_C_CDNS_71 $T=104420 207075 0 0 $X=104230 $Y=206675
X638 3 VIA1_C_CDNS_71 $T=105250 58310 0 0 $X=105060 $Y=57910
X639 3 VIA1_C_CDNS_71 $T=105250 80410 0 0 $X=105060 $Y=80010
X640 3 VIA1_C_CDNS_71 $T=105250 102510 0 0 $X=105060 $Y=102110
X641 20 VIA1_C_CDNS_71 $T=105690 173675 0 0 $X=105500 $Y=173275
X642 20 VIA1_C_CDNS_71 $T=105690 189295 0 0 $X=105500 $Y=188895
X643 20 VIA1_C_CDNS_71 $T=105690 204915 0 0 $X=105500 $Y=204515
X644 12 VIA1_C_CDNS_71 $T=106520 64790 0 0 $X=106330 $Y=64390
X645 12 VIA1_C_CDNS_71 $T=106520 86890 0 0 $X=106330 $Y=86490
X646 10 VIA1_C_CDNS_71 $T=106520 106830 0 0 $X=106330 $Y=106430
X647 2 VIA1_C_CDNS_71 $T=106960 174755 0 0 $X=106770 $Y=174355
X648 2 VIA1_C_CDNS_71 $T=106960 190375 0 0 $X=106770 $Y=189975
X649 2 VIA1_C_CDNS_71 $T=106960 205995 0 0 $X=106770 $Y=205595
X650 15 VIA1_C_CDNS_71 $T=109000 65870 0 0 $X=108810 $Y=65470
X651 15 VIA1_C_CDNS_71 $T=109000 87970 0 0 $X=108810 $Y=87570
X652 17 VIA1_C_CDNS_71 $T=109000 112230 0 0 $X=108810 $Y=111830
X653 14 VIA1_C_CDNS_71 $T=109440 177995 0 0 $X=109250 $Y=177595
X654 14 VIA1_C_CDNS_71 $T=109440 193615 0 0 $X=109250 $Y=193215
X655 16 VIA1_C_CDNS_71 $T=109440 210315 0 0 $X=109250 $Y=209915
X656 3 VIA1_C_CDNS_71 $T=110270 58310 0 0 $X=110080 $Y=57910
X657 3 VIA1_C_CDNS_71 $T=110270 80410 0 0 $X=110080 $Y=80010
X658 3 VIA1_C_CDNS_71 $T=110270 102510 0 0 $X=110080 $Y=102110
X659 20 VIA1_C_CDNS_71 $T=110710 173675 0 0 $X=110520 $Y=173275
X660 20 VIA1_C_CDNS_71 $T=110710 189295 0 0 $X=110520 $Y=188895
X661 20 VIA1_C_CDNS_71 $T=110710 204915 0 0 $X=110520 $Y=204515
X662 14 VIA1_C_CDNS_71 $T=111540 66950 0 0 $X=111350 $Y=66550
X663 14 VIA1_C_CDNS_71 $T=111540 89050 0 0 $X=111350 $Y=88650
X664 16 VIA1_C_CDNS_71 $T=111540 113310 0 0 $X=111350 $Y=112910
X665 2 VIA1_C_CDNS_71 $T=111980 174755 0 0 $X=111790 $Y=174355
X666 2 VIA1_C_CDNS_71 $T=111980 190375 0 0 $X=111790 $Y=189975
X667 2 VIA1_C_CDNS_71 $T=111980 205995 0 0 $X=111790 $Y=205595
X668 17 VIA1_C_CDNS_71 $T=114020 68030 0 0 $X=113830 $Y=67630
X669 17 VIA1_C_CDNS_71 $T=114020 90130 0 0 $X=113830 $Y=89730
X670 19 VIA1_C_CDNS_71 $T=114020 114390 0 0 $X=113830 $Y=113990
X671 16 VIA1_C_CDNS_71 $T=114460 179075 0 0 $X=114270 $Y=178675
X672 16 VIA1_C_CDNS_71 $T=114460 194695 0 0 $X=114270 $Y=194295
X673 18 VIA1_C_CDNS_71 $T=114460 211395 0 0 $X=114270 $Y=210995
X674 3 VIA1_C_CDNS_71 $T=115290 58310 0 0 $X=115100 $Y=57910
X675 3 VIA1_C_CDNS_71 $T=115290 80410 0 0 $X=115100 $Y=80010
X676 3 VIA1_C_CDNS_71 $T=115290 102510 0 0 $X=115100 $Y=102110
X677 20 VIA1_C_CDNS_71 $T=115730 173675 0 0 $X=115540 $Y=173275
X678 20 VIA1_C_CDNS_71 $T=115730 189295 0 0 $X=115540 $Y=188895
X679 20 VIA1_C_CDNS_71 $T=115730 204915 0 0 $X=115540 $Y=204515
X680 16 VIA1_C_CDNS_71 $T=116560 69110 0 0 $X=116370 $Y=68710
X681 16 VIA1_C_CDNS_71 $T=116560 91210 0 0 $X=116370 $Y=90810
X682 18 VIA1_C_CDNS_71 $T=116560 115470 0 0 $X=116370 $Y=115070
X683 2 VIA1_C_CDNS_71 $T=117000 174755 0 0 $X=116810 $Y=174355
X684 2 VIA1_C_CDNS_71 $T=117000 190375 0 0 $X=116810 $Y=189975
X685 2 VIA1_C_CDNS_71 $T=117000 205995 0 0 $X=116810 $Y=205595
X686 15 VIA1_C_CDNS_71 $T=119040 65870 0 0 $X=118850 $Y=65470
X687 15 VIA1_C_CDNS_71 $T=119040 87970 0 0 $X=118850 $Y=87570
X688 19 VIA1_C_CDNS_71 $T=119040 114390 0 0 $X=118850 $Y=113990
X689 14 VIA1_C_CDNS_71 $T=119480 177995 0 0 $X=119290 $Y=177595
X690 14 VIA1_C_CDNS_71 $T=119480 193615 0 0 $X=119290 $Y=193215
X691 18 VIA1_C_CDNS_71 $T=119480 211395 0 0 $X=119290 $Y=210995
X692 3 VIA1_C_CDNS_71 $T=120310 58310 0 0 $X=120120 $Y=57910
X693 3 VIA1_C_CDNS_71 $T=120310 80410 0 0 $X=120120 $Y=80010
X694 3 VIA1_C_CDNS_71 $T=120310 102510 0 0 $X=120120 $Y=102110
X695 20 VIA1_C_CDNS_71 $T=120750 173675 0 0 $X=120560 $Y=173275
X696 20 VIA1_C_CDNS_71 $T=120750 189295 0 0 $X=120560 $Y=188895
X697 20 VIA1_C_CDNS_71 $T=120750 204915 0 0 $X=120560 $Y=204515
X698 14 VIA1_C_CDNS_71 $T=121580 66950 0 0 $X=121390 $Y=66550
X699 14 VIA1_C_CDNS_71 $T=121580 89050 0 0 $X=121390 $Y=88650
X700 18 VIA1_C_CDNS_71 $T=121580 115470 0 0 $X=121390 $Y=115070
X701 2 VIA1_C_CDNS_71 $T=122020 174755 0 0 $X=121830 $Y=174355
X702 2 VIA1_C_CDNS_71 $T=122020 190375 0 0 $X=121830 $Y=189975
X703 2 VIA1_C_CDNS_71 $T=122020 205995 0 0 $X=121830 $Y=205595
X704 17 VIA1_C_CDNS_71 $T=124060 68030 0 0 $X=123870 $Y=67630
X705 17 VIA1_C_CDNS_71 $T=124060 90130 0 0 $X=123870 $Y=89730
X706 19 VIA1_C_CDNS_71 $T=124060 114390 0 0 $X=123870 $Y=113990
X707 16 VIA1_C_CDNS_71 $T=124500 179075 0 0 $X=124310 $Y=178675
X708 16 VIA1_C_CDNS_71 $T=124500 194695 0 0 $X=124310 $Y=194295
X709 18 VIA1_C_CDNS_71 $T=124500 211395 0 0 $X=124310 $Y=210995
X710 3 VIA1_C_CDNS_71 $T=125330 58310 0 0 $X=125140 $Y=57910
X711 3 VIA1_C_CDNS_71 $T=125330 80410 0 0 $X=125140 $Y=80010
X712 3 VIA1_C_CDNS_71 $T=125330 102510 0 0 $X=125140 $Y=102110
X713 20 VIA1_C_CDNS_71 $T=125770 173675 0 0 $X=125580 $Y=173275
X714 20 VIA1_C_CDNS_71 $T=125770 189295 0 0 $X=125580 $Y=188895
X715 20 VIA1_C_CDNS_71 $T=125770 204915 0 0 $X=125580 $Y=204515
X716 16 VIA1_C_CDNS_71 $T=126600 69110 0 0 $X=126410 $Y=68710
X717 16 VIA1_C_CDNS_71 $T=126600 91210 0 0 $X=126410 $Y=90810
X718 18 VIA1_C_CDNS_71 $T=126600 115470 0 0 $X=126410 $Y=115070
X719 2 VIA1_C_CDNS_71 $T=127040 174755 0 0 $X=126850 $Y=174355
X720 2 VIA1_C_CDNS_71 $T=127040 190375 0 0 $X=126850 $Y=189975
X721 2 VIA1_C_CDNS_71 $T=127040 205995 0 0 $X=126850 $Y=205595
X722 15 VIA1_C_CDNS_71 $T=129080 65870 0 0 $X=128890 $Y=65470
X723 15 VIA1_C_CDNS_71 $T=129080 87970 0 0 $X=128890 $Y=87570
X724 19 VIA1_C_CDNS_71 $T=129080 114390 0 0 $X=128890 $Y=113990
X725 14 VIA1_C_CDNS_71 $T=129520 177995 0 0 $X=129330 $Y=177595
X726 14 VIA1_C_CDNS_71 $T=129520 193615 0 0 $X=129330 $Y=193215
X727 18 VIA1_C_CDNS_71 $T=129520 211395 0 0 $X=129330 $Y=210995
X728 3 VIA1_C_CDNS_71 $T=130350 58310 0 0 $X=130160 $Y=57910
X729 3 VIA1_C_CDNS_71 $T=130350 80410 0 0 $X=130160 $Y=80010
X730 3 VIA1_C_CDNS_71 $T=130350 102510 0 0 $X=130160 $Y=102110
X731 20 VIA1_C_CDNS_71 $T=130790 173675 0 0 $X=130600 $Y=173275
X732 20 VIA1_C_CDNS_71 $T=130790 189295 0 0 $X=130600 $Y=188895
X733 20 VIA1_C_CDNS_71 $T=130790 204915 0 0 $X=130600 $Y=204515
X734 14 VIA1_C_CDNS_71 $T=131620 66950 0 0 $X=131430 $Y=66550
X735 14 VIA1_C_CDNS_71 $T=131620 89050 0 0 $X=131430 $Y=88650
X736 18 VIA1_C_CDNS_71 $T=131620 115470 0 0 $X=131430 $Y=115070
X737 2 VIA1_C_CDNS_71 $T=132060 174755 0 0 $X=131870 $Y=174355
X738 2 VIA1_C_CDNS_71 $T=132060 190375 0 0 $X=131870 $Y=189975
X739 2 VIA1_C_CDNS_71 $T=132060 205995 0 0 $X=131870 $Y=205595
X740 17 VIA1_C_CDNS_71 $T=134100 68030 0 0 $X=133910 $Y=67630
X741 17 VIA1_C_CDNS_71 $T=134100 90130 0 0 $X=133910 $Y=89730
X742 19 VIA1_C_CDNS_71 $T=134100 114390 0 0 $X=133910 $Y=113990
X743 2 VIA1_C_CDNS_71 $T=134540 174755 0 0 $X=134350 $Y=174355
X744 2 VIA1_C_CDNS_71 $T=134540 190375 0 0 $X=134350 $Y=189975
X745 2 VIA1_C_CDNS_71 $T=134540 205995 0 0 $X=134350 $Y=205595
X746 3 VIA1_C_CDNS_71 $T=135370 58310 0 0 $X=135180 $Y=57910
X747 3 VIA1_C_CDNS_71 $T=135370 80410 0 0 $X=135180 $Y=80010
X748 3 VIA1_C_CDNS_71 $T=135370 102510 0 0 $X=135180 $Y=102110
X749 20 VIA1_C_CDNS_71 $T=135810 173675 0 0 $X=135620 $Y=173275
X750 20 VIA1_C_CDNS_71 $T=135810 189295 0 0 $X=135620 $Y=188895
X751 20 VIA1_C_CDNS_71 $T=135810 204915 0 0 $X=135620 $Y=204515
X752 16 VIA1_C_CDNS_71 $T=136640 69110 0 0 $X=136450 $Y=68710
X753 16 VIA1_C_CDNS_71 $T=136640 91210 0 0 $X=136450 $Y=90810
X754 18 VIA1_C_CDNS_71 $T=136640 115470 0 0 $X=136450 $Y=115070
X755 16 VIA1_C_CDNS_71 $T=137080 179075 0 0 $X=136890 $Y=178675
X756 16 VIA1_C_CDNS_71 $T=137080 194695 0 0 $X=136890 $Y=194295
X757 18 VIA1_C_CDNS_71 $T=137080 211395 0 0 $X=136890 $Y=210995
X758 15 VIA1_C_CDNS_71 $T=139120 65870 0 0 $X=138930 $Y=65470
X759 15 VIA1_C_CDNS_71 $T=139120 87970 0 0 $X=138930 $Y=87570
X760 19 VIA1_C_CDNS_71 $T=139120 114390 0 0 $X=138930 $Y=113990
X761 2 VIA1_C_CDNS_71 $T=139560 174755 0 0 $X=139370 $Y=174355
X762 2 VIA1_C_CDNS_71 $T=139560 190375 0 0 $X=139370 $Y=189975
X763 2 VIA1_C_CDNS_71 $T=139560 205995 0 0 $X=139370 $Y=205595
X764 3 VIA1_C_CDNS_71 $T=140390 58310 0 0 $X=140200 $Y=57910
X765 3 VIA1_C_CDNS_71 $T=140390 80410 0 0 $X=140200 $Y=80010
X766 3 VIA1_C_CDNS_71 $T=140390 102510 0 0 $X=140200 $Y=102110
X767 20 VIA1_C_CDNS_71 $T=140830 173675 0 0 $X=140640 $Y=173275
X768 20 VIA1_C_CDNS_71 $T=140830 189295 0 0 $X=140640 $Y=188895
X769 20 VIA1_C_CDNS_71 $T=140830 204915 0 0 $X=140640 $Y=204515
X770 14 VIA1_C_CDNS_71 $T=141660 66950 0 0 $X=141470 $Y=66550
X771 14 VIA1_C_CDNS_71 $T=141660 89050 0 0 $X=141470 $Y=88650
X772 18 VIA1_C_CDNS_71 $T=141660 115470 0 0 $X=141470 $Y=115070
X773 14 VIA1_C_CDNS_71 $T=142100 177995 0 0 $X=141910 $Y=177595
X774 14 VIA1_C_CDNS_71 $T=142100 193615 0 0 $X=141910 $Y=193215
X775 18 VIA1_C_CDNS_71 $T=142100 211395 0 0 $X=141910 $Y=210995
X776 17 VIA1_C_CDNS_71 $T=144140 68030 0 0 $X=143950 $Y=67630
X777 17 VIA1_C_CDNS_71 $T=144140 90130 0 0 $X=143950 $Y=89730
X778 19 VIA1_C_CDNS_71 $T=144140 114390 0 0 $X=143950 $Y=113990
X779 16 VIA1_C_CDNS_71 $T=144580 179075 0 0 $X=144390 $Y=178675
X780 16 VIA1_C_CDNS_71 $T=144580 194695 0 0 $X=144390 $Y=194295
X781 18 VIA1_C_CDNS_71 $T=144580 211395 0 0 $X=144390 $Y=210995
X782 3 VIA1_C_CDNS_71 $T=145410 58310 0 0 $X=145220 $Y=57910
X783 3 VIA1_C_CDNS_71 $T=145410 80410 0 0 $X=145220 $Y=80010
X784 3 VIA1_C_CDNS_71 $T=145410 102510 0 0 $X=145220 $Y=102110
X785 20 VIA1_C_CDNS_71 $T=145850 173675 0 0 $X=145660 $Y=173275
X786 20 VIA1_C_CDNS_71 $T=145850 189295 0 0 $X=145660 $Y=188895
X787 20 VIA1_C_CDNS_71 $T=145850 204915 0 0 $X=145660 $Y=204515
X788 16 VIA1_C_CDNS_71 $T=146680 69110 0 0 $X=146490 $Y=68710
X789 16 VIA1_C_CDNS_71 $T=146680 91210 0 0 $X=146490 $Y=90810
X790 18 VIA1_C_CDNS_71 $T=146680 115470 0 0 $X=146490 $Y=115070
X791 2 VIA1_C_CDNS_71 $T=147120 174755 0 0 $X=146930 $Y=174355
X792 2 VIA1_C_CDNS_71 $T=147120 190375 0 0 $X=146930 $Y=189975
X793 2 VIA1_C_CDNS_71 $T=147120 205995 0 0 $X=146930 $Y=205595
X794 19 VIA1_C_CDNS_71 $T=149160 70190 0 0 $X=148970 $Y=69790
X795 19 VIA1_C_CDNS_71 $T=149160 92290 0 0 $X=148970 $Y=91890
X796 19 VIA1_C_CDNS_71 $T=149160 114390 0 0 $X=148970 $Y=113990
X797 18 VIA1_C_CDNS_71 $T=149600 180155 0 0 $X=149410 $Y=179755
X798 18 VIA1_C_CDNS_71 $T=149600 195775 0 0 $X=149410 $Y=195375
X799 18 VIA1_C_CDNS_71 $T=149600 211395 0 0 $X=149410 $Y=210995
X800 3 VIA1_C_CDNS_71 $T=150430 58310 0 0 $X=150240 $Y=57910
X801 3 VIA1_C_CDNS_71 $T=150430 80410 0 0 $X=150240 $Y=80010
X802 3 VIA1_C_CDNS_71 $T=150430 102510 0 0 $X=150240 $Y=102110
X803 20 VIA1_C_CDNS_71 $T=150870 173675 0 0 $X=150680 $Y=173275
X804 20 VIA1_C_CDNS_71 $T=150870 189295 0 0 $X=150680 $Y=188895
X805 20 VIA1_C_CDNS_71 $T=150870 204915 0 0 $X=150680 $Y=204515
X806 18 VIA1_C_CDNS_71 $T=151700 71270 0 0 $X=151510 $Y=70870
X807 18 VIA1_C_CDNS_71 $T=151700 93370 0 0 $X=151510 $Y=92970
X808 18 VIA1_C_CDNS_71 $T=151700 115470 0 0 $X=151510 $Y=115070
X809 2 VIA1_C_CDNS_71 $T=152140 174755 0 0 $X=151950 $Y=174355
X810 2 VIA1_C_CDNS_71 $T=152140 190375 0 0 $X=151950 $Y=189975
X811 2 VIA1_C_CDNS_71 $T=152140 205995 0 0 $X=151950 $Y=205595
X812 17 VIA1_C_CDNS_71 $T=154180 68030 0 0 $X=153990 $Y=67630
X813 17 VIA1_C_CDNS_71 $T=154180 90130 0 0 $X=153990 $Y=89730
X814 19 VIA1_C_CDNS_71 $T=154180 114390 0 0 $X=153990 $Y=113990
X815 16 VIA1_C_CDNS_71 $T=154620 179075 0 0 $X=154430 $Y=178675
X816 16 VIA1_C_CDNS_71 $T=154620 194695 0 0 $X=154430 $Y=194295
X817 18 VIA1_C_CDNS_71 $T=154620 211395 0 0 $X=154430 $Y=210995
X818 3 VIA1_C_CDNS_71 $T=155450 58310 0 0 $X=155260 $Y=57910
X819 3 VIA1_C_CDNS_71 $T=155450 80410 0 0 $X=155260 $Y=80010
X820 3 VIA1_C_CDNS_71 $T=155450 102510 0 0 $X=155260 $Y=102110
X821 20 VIA1_C_CDNS_71 $T=155890 173675 0 0 $X=155700 $Y=173275
X822 20 VIA1_C_CDNS_71 $T=155890 189295 0 0 $X=155700 $Y=188895
X823 20 VIA1_C_CDNS_71 $T=155890 204915 0 0 $X=155700 $Y=204515
X824 16 VIA1_C_CDNS_71 $T=156720 69110 0 0 $X=156530 $Y=68710
X825 16 VIA1_C_CDNS_71 $T=156720 91210 0 0 $X=156530 $Y=90810
X826 18 VIA1_C_CDNS_71 $T=156720 115470 0 0 $X=156530 $Y=115070
X827 2 VIA1_C_CDNS_71 $T=157160 174755 0 0 $X=156970 $Y=174355
X828 2 VIA1_C_CDNS_71 $T=157160 190375 0 0 $X=156970 $Y=189975
X829 2 VIA1_C_CDNS_71 $T=157160 205995 0 0 $X=156970 $Y=205595
X830 19 VIA1_C_CDNS_71 $T=159200 70190 0 0 $X=159010 $Y=69790
X831 19 VIA1_C_CDNS_71 $T=159200 92290 0 0 $X=159010 $Y=91890
X832 19 VIA1_C_CDNS_71 $T=159200 114390 0 0 $X=159010 $Y=113990
X833 18 VIA1_C_CDNS_71 $T=159640 180155 0 0 $X=159450 $Y=179755
X834 18 VIA1_C_CDNS_71 $T=159640 195775 0 0 $X=159450 $Y=195375
X835 18 VIA1_C_CDNS_71 $T=159640 211395 0 0 $X=159450 $Y=210995
X836 3 VIA1_C_CDNS_71 $T=160470 58310 0 0 $X=160280 $Y=57910
X837 3 VIA1_C_CDNS_71 $T=160470 80410 0 0 $X=160280 $Y=80010
X838 3 VIA1_C_CDNS_71 $T=160470 102510 0 0 $X=160280 $Y=102110
X839 20 VIA1_C_CDNS_71 $T=160910 173675 0 0 $X=160720 $Y=173275
X840 20 VIA1_C_CDNS_71 $T=160910 189295 0 0 $X=160720 $Y=188895
X841 20 VIA1_C_CDNS_71 $T=160910 204915 0 0 $X=160720 $Y=204515
X842 18 VIA1_C_CDNS_71 $T=161740 71270 0 0 $X=161550 $Y=70870
X843 18 VIA1_C_CDNS_71 $T=161740 93370 0 0 $X=161550 $Y=92970
X844 18 VIA1_C_CDNS_71 $T=161740 115470 0 0 $X=161550 $Y=115070
X845 2 VIA1_C_CDNS_71 $T=162180 174755 0 0 $X=161990 $Y=174355
X846 2 VIA1_C_CDNS_71 $T=162180 190375 0 0 $X=161990 $Y=189975
X847 2 VIA1_C_CDNS_71 $T=162180 205995 0 0 $X=161990 $Y=205595
X848 17 VIA1_C_CDNS_71 $T=164220 68030 0 0 $X=164030 $Y=67630
X849 17 VIA1_C_CDNS_71 $T=164220 90130 0 0 $X=164030 $Y=89730
X850 19 VIA1_C_CDNS_71 $T=164220 114390 0 0 $X=164030 $Y=113990
X851 16 VIA1_C_CDNS_71 $T=164660 179075 0 0 $X=164470 $Y=178675
X852 16 VIA1_C_CDNS_71 $T=164660 194695 0 0 $X=164470 $Y=194295
X853 18 VIA1_C_CDNS_71 $T=164660 211395 0 0 $X=164470 $Y=210995
X854 3 VIA1_C_CDNS_71 $T=165490 58310 0 0 $X=165300 $Y=57910
X855 3 VIA1_C_CDNS_71 $T=165490 80410 0 0 $X=165300 $Y=80010
X856 3 VIA1_C_CDNS_71 $T=165490 102510 0 0 $X=165300 $Y=102110
X857 20 VIA1_C_CDNS_71 $T=165930 173675 0 0 $X=165740 $Y=173275
X858 20 VIA1_C_CDNS_71 $T=165930 189295 0 0 $X=165740 $Y=188895
X859 20 VIA1_C_CDNS_71 $T=165930 204915 0 0 $X=165740 $Y=204515
X860 16 VIA1_C_CDNS_71 $T=166760 69110 0 0 $X=166570 $Y=68710
X861 16 VIA1_C_CDNS_71 $T=166760 91210 0 0 $X=166570 $Y=90810
X862 18 VIA1_C_CDNS_71 $T=166760 115470 0 0 $X=166570 $Y=115070
X863 2 VIA1_C_CDNS_71 $T=167200 174755 0 0 $X=167010 $Y=174355
X864 2 VIA1_C_CDNS_71 $T=167200 190375 0 0 $X=167010 $Y=189975
X865 2 VIA1_C_CDNS_71 $T=167200 205995 0 0 $X=167010 $Y=205595
X866 19 VIA1_C_CDNS_71 $T=169240 70190 0 0 $X=169050 $Y=69790
X867 19 VIA1_C_CDNS_71 $T=169240 92290 0 0 $X=169050 $Y=91890
X868 19 VIA1_C_CDNS_71 $T=169240 114390 0 0 $X=169050 $Y=113990
X869 18 VIA1_C_CDNS_71 $T=169680 180155 0 0 $X=169490 $Y=179755
X870 18 VIA1_C_CDNS_71 $T=169680 195775 0 0 $X=169490 $Y=195375
X871 18 VIA1_C_CDNS_71 $T=169680 211395 0 0 $X=169490 $Y=210995
X872 3 VIA1_C_CDNS_71 $T=170510 58310 0 0 $X=170320 $Y=57910
X873 3 VIA1_C_CDNS_71 $T=170510 80410 0 0 $X=170320 $Y=80010
X874 3 VIA1_C_CDNS_71 $T=170510 102510 0 0 $X=170320 $Y=102110
X875 20 VIA1_C_CDNS_71 $T=170950 173675 0 0 $X=170760 $Y=173275
X876 20 VIA1_C_CDNS_71 $T=170950 189295 0 0 $X=170760 $Y=188895
X877 20 VIA1_C_CDNS_71 $T=170950 204915 0 0 $X=170760 $Y=204515
X878 18 VIA1_C_CDNS_71 $T=171780 71270 0 0 $X=171590 $Y=70870
X879 18 VIA1_C_CDNS_71 $T=171780 93370 0 0 $X=171590 $Y=92970
X880 18 VIA1_C_CDNS_71 $T=171780 115470 0 0 $X=171590 $Y=115070
X881 2 VIA1_C_CDNS_71 $T=172220 174755 0 0 $X=172030 $Y=174355
X882 2 VIA1_C_CDNS_71 $T=172220 190375 0 0 $X=172030 $Y=189975
X883 2 VIA1_C_CDNS_71 $T=172220 205995 0 0 $X=172030 $Y=205595
X884 17 VIA1_C_CDNS_71 $T=174260 68030 0 0 $X=174070 $Y=67630
X885 17 VIA1_C_CDNS_71 $T=174260 90130 0 0 $X=174070 $Y=89730
X886 19 VIA1_C_CDNS_71 $T=174260 114390 0 0 $X=174070 $Y=113990
X887 16 VIA1_C_CDNS_71 $T=174700 179075 0 0 $X=174510 $Y=178675
X888 16 VIA1_C_CDNS_71 $T=174700 194695 0 0 $X=174510 $Y=194295
X889 18 VIA1_C_CDNS_71 $T=174700 211395 0 0 $X=174510 $Y=210995
X890 3 VIA1_C_CDNS_71 $T=175530 58310 0 0 $X=175340 $Y=57910
X891 3 VIA1_C_CDNS_71 $T=175530 80410 0 0 $X=175340 $Y=80010
X892 3 VIA1_C_CDNS_71 $T=175530 102510 0 0 $X=175340 $Y=102110
X893 20 VIA1_C_CDNS_71 $T=175970 173675 0 0 $X=175780 $Y=173275
X894 20 VIA1_C_CDNS_71 $T=175970 189295 0 0 $X=175780 $Y=188895
X895 20 VIA1_C_CDNS_71 $T=175970 204915 0 0 $X=175780 $Y=204515
X896 16 VIA1_C_CDNS_71 $T=176800 69110 0 0 $X=176610 $Y=68710
X897 16 VIA1_C_CDNS_71 $T=176800 91210 0 0 $X=176610 $Y=90810
X898 18 VIA1_C_CDNS_71 $T=176800 115470 0 0 $X=176610 $Y=115070
X899 2 VIA1_C_CDNS_71 $T=177240 174755 0 0 $X=177050 $Y=174355
X900 2 VIA1_C_CDNS_71 $T=177240 190375 0 0 $X=177050 $Y=189975
X901 2 VIA1_C_CDNS_71 $T=177240 205995 0 0 $X=177050 $Y=205595
X902 2 VIA1_C_CDNS_71 $T=179720 174755 0 0 $X=179530 $Y=174355
X903 2 VIA1_C_CDNS_71 $T=179720 190375 0 0 $X=179530 $Y=189975
X904 2 VIA1_C_CDNS_71 $T=179720 205995 0 0 $X=179530 $Y=205595
X905 2 VIA1_C_CDNS_71 $T=180990 174755 0 0 $X=180800 $Y=174355
X906 2 VIA1_C_CDNS_71 $T=180990 190375 0 0 $X=180800 $Y=189975
X907 2 VIA1_C_CDNS_71 $T=180990 205995 0 0 $X=180800 $Y=205595
X908 2 VIA1_C_CDNS_71 $T=182260 174755 0 0 $X=182070 $Y=174355
X909 2 VIA1_C_CDNS_71 $T=182260 190375 0 0 $X=182070 $Y=189975
X910 2 VIA1_C_CDNS_71 $T=182260 205995 0 0 $X=182070 $Y=205595
X911 2 VIA2_C_CDNS_72 $T=-4850 27460 0 0 $X=-5560 $Y=26800
X912 2 VIA2_C_CDNS_72 $T=-4850 146320 0 0 $X=-5560 $Y=145660
X913 3 VIA2_C_CDNS_72 $T=-3070 29240 0 0 $X=-3780 $Y=28580
X914 3 VIA2_C_CDNS_72 $T=-3070 124960 0 0 $X=-3780 $Y=124300
X915 11 VIA2_C_CDNS_72 $T=-1290 32800 0 0 $X=-2000 $Y=32140
X916 11 VIA2_C_CDNS_72 $T=-1290 126740 0 0 $X=-2000 $Y=126080
X917 10 VIA2_C_CDNS_72 $T=490 34580 0 0 $X=-220 $Y=33920
X918 10 VIA2_C_CDNS_72 $T=490 128520 0 0 $X=-220 $Y=127860
X919 2 VIA2_C_CDNS_72 $T=1250 153505 0 0 $X=540 $Y=152845
X920 2 VIA2_C_CDNS_72 $T=1250 231565 0 0 $X=540 $Y=230905
X921 13 VIA2_C_CDNS_72 $T=2270 36360 0 0 $X=1560 $Y=35700
X922 13 VIA2_C_CDNS_72 $T=2270 130300 0 0 $X=1560 $Y=129640
X923 10 VIA2_C_CDNS_72 $T=3030 157065 0 0 $X=2320 $Y=156405
X924 10 VIA2_C_CDNS_72 $T=3030 229785 0 0 $X=2320 $Y=229125
X925 12 VIA2_C_CDNS_72 $T=4050 38140 0 0 $X=3340 $Y=37480
X926 12 VIA2_C_CDNS_72 $T=4050 132080 0 0 $X=3340 $Y=131420
X927 12 VIA2_C_CDNS_72 $T=4810 158845 0 0 $X=4100 $Y=158185
X928 12 VIA2_C_CDNS_72 $T=4810 228005 0 0 $X=4100 $Y=227345
X929 15 VIA2_C_CDNS_72 $T=5830 39920 0 0 $X=5120 $Y=39260
X930 15 VIA2_C_CDNS_72 $T=5830 133860 0 0 $X=5120 $Y=133200
X931 14 VIA2_C_CDNS_72 $T=6590 160625 0 0 $X=5880 $Y=159965
X932 14 VIA2_C_CDNS_72 $T=6590 226225 0 0 $X=5880 $Y=225565
X933 14 VIA2_C_CDNS_72 $T=7610 41700 0 0 $X=6900 $Y=41040
X934 14 VIA2_C_CDNS_72 $T=7610 135640 0 0 $X=6900 $Y=134980
X935 16 VIA2_C_CDNS_72 $T=8370 162405 0 0 $X=7660 $Y=161745
X936 16 VIA2_C_CDNS_72 $T=8370 224445 0 0 $X=7660 $Y=223785
X937 17 VIA2_C_CDNS_72 $T=9390 43480 0 0 $X=8680 $Y=42820
X938 17 VIA2_C_CDNS_72 $T=9390 137420 0 0 $X=8680 $Y=136760
X939 18 VIA2_C_CDNS_72 $T=10150 164185 0 0 $X=9440 $Y=163525
X940 18 VIA2_C_CDNS_72 $T=10150 222665 0 0 $X=9440 $Y=222005
X941 16 VIA2_C_CDNS_72 $T=11170 45260 0 0 $X=10460 $Y=44600
X942 16 VIA2_C_CDNS_72 $T=11170 139200 0 0 $X=10460 $Y=138540
X943 20 VIA2_C_CDNS_72 $T=11930 155285 0 0 $X=11220 $Y=154625
X944 20 VIA2_C_CDNS_72 $T=11930 220885 0 0 $X=11220 $Y=220225
X945 19 VIA2_C_CDNS_72 $T=12950 47040 0 0 $X=12240 $Y=46380
X946 19 VIA2_C_CDNS_72 $T=12950 140980 0 0 $X=12240 $Y=140320
X947 18 VIA2_C_CDNS_72 $T=14730 48820 0 0 $X=14020 $Y=48160
X948 18 VIA2_C_CDNS_72 $T=14730 142760 0 0 $X=14020 $Y=142100
X949 20 VIA2_C_CDNS_72 $T=16510 31020 0 0 $X=15800 $Y=30360
X950 20 VIA2_C_CDNS_72 $T=16510 144540 0 0 $X=15800 $Y=143880
X951 3 VIA2_C_CDNS_72 $T=178930 29240 0 0 $X=178220 $Y=28580
X952 3 VIA2_C_CDNS_72 $T=178930 124960 0 0 $X=178220 $Y=124300
X953 11 VIA2_C_CDNS_72 $T=180710 32800 0 0 $X=180000 $Y=32140
X954 11 VIA2_C_CDNS_72 $T=180710 126740 0 0 $X=180000 $Y=126080
X955 10 VIA2_C_CDNS_72 $T=182490 34580 0 0 $X=181780 $Y=33920
X956 10 VIA2_C_CDNS_72 $T=182490 128520 0 0 $X=181780 $Y=127860
X957 13 VIA2_C_CDNS_72 $T=184270 36360 0 0 $X=183560 $Y=35700
X958 13 VIA2_C_CDNS_72 $T=184270 130300 0 0 $X=183560 $Y=129640
X959 20 VIA2_C_CDNS_72 $T=184390 155285 0 0 $X=183680 $Y=154625
X960 20 VIA2_C_CDNS_72 $T=184390 220885 0 0 $X=183680 $Y=220225
X961 12 VIA2_C_CDNS_72 $T=186050 38140 0 0 $X=185340 $Y=37480
X962 12 VIA2_C_CDNS_72 $T=186050 132080 0 0 $X=185340 $Y=131420
X963 18 VIA2_C_CDNS_72 $T=186170 164185 0 0 $X=185460 $Y=163525
X964 18 VIA2_C_CDNS_72 $T=186170 222665 0 0 $X=185460 $Y=222005
X965 15 VIA2_C_CDNS_72 $T=187830 39920 0 0 $X=187120 $Y=39260
X966 15 VIA2_C_CDNS_72 $T=187830 133860 0 0 $X=187120 $Y=133200
X967 16 VIA2_C_CDNS_72 $T=187950 162405 0 0 $X=187240 $Y=161745
X968 16 VIA2_C_CDNS_72 $T=187950 224445 0 0 $X=187240 $Y=223785
X969 14 VIA2_C_CDNS_72 $T=189610 41700 0 0 $X=188900 $Y=41040
X970 14 VIA2_C_CDNS_72 $T=189610 135640 0 0 $X=188900 $Y=134980
X971 14 VIA2_C_CDNS_72 $T=189730 160625 0 0 $X=189020 $Y=159965
X972 14 VIA2_C_CDNS_72 $T=189730 226225 0 0 $X=189020 $Y=225565
X973 17 VIA2_C_CDNS_72 $T=191390 43480 0 0 $X=190680 $Y=42820
X974 17 VIA2_C_CDNS_72 $T=191390 137420 0 0 $X=190680 $Y=136760
X975 12 VIA2_C_CDNS_72 $T=191510 158845 0 0 $X=190800 $Y=158185
X976 12 VIA2_C_CDNS_72 $T=191510 228005 0 0 $X=190800 $Y=227345
X977 16 VIA2_C_CDNS_72 $T=193170 45260 0 0 $X=192460 $Y=44600
X978 16 VIA2_C_CDNS_72 $T=193170 139200 0 0 $X=192460 $Y=138540
X979 10 VIA2_C_CDNS_72 $T=193290 157065 0 0 $X=192580 $Y=156405
X980 10 VIA2_C_CDNS_72 $T=193290 229785 0 0 $X=192580 $Y=229125
X981 19 VIA2_C_CDNS_72 $T=194950 47040 0 0 $X=194240 $Y=46380
X982 19 VIA2_C_CDNS_72 $T=194950 140980 0 0 $X=194240 $Y=140320
X983 2 VIA2_C_CDNS_72 $T=195070 153505 0 0 $X=194360 $Y=152845
X984 2 VIA2_C_CDNS_72 $T=195070 231565 0 0 $X=194360 $Y=230905
X985 18 VIA2_C_CDNS_72 $T=196730 48820 0 0 $X=196020 $Y=48160
X986 18 VIA2_C_CDNS_72 $T=196730 142760 0 0 $X=196020 $Y=142100
X987 20 VIA2_C_CDNS_72 $T=198510 31020 0 0 $X=197800 $Y=30360
X988 20 VIA2_C_CDNS_72 $T=198510 144540 0 0 $X=197800 $Y=143880
X989 2 VIA2_C_CDNS_72 $T=200290 27460 0 0 $X=199580 $Y=26800
X990 2 VIA2_C_CDNS_72 $T=200290 146320 0 0 $X=199580 $Y=145660
X991 2 VIA2_C_CDNS_73 $T=-4850 59390 0 0 $X=-5560 $Y=58990
X992 2 VIA2_C_CDNS_73 $T=-4850 81490 0 0 $X=-5560 $Y=81090
X993 2 VIA2_C_CDNS_73 $T=-4850 103590 0 0 $X=-5560 $Y=103190
X994 3 VIA2_C_CDNS_73 $T=-3070 58310 0 0 $X=-3780 $Y=57910
X995 3 VIA2_C_CDNS_73 $T=-3070 80410 0 0 $X=-3780 $Y=80010
X996 3 VIA2_C_CDNS_73 $T=-3070 102510 0 0 $X=-3780 $Y=102110
X997 11 VIA2_C_CDNS_73 $T=-1290 61550 0 0 $X=-2000 $Y=61150
X998 11 VIA2_C_CDNS_73 $T=-1290 83650 0 0 $X=-2000 $Y=83250
X999 11 VIA2_C_CDNS_73 $T=-1290 105750 0 0 $X=-2000 $Y=105350
X1000 10 VIA2_C_CDNS_73 $T=490 62630 0 0 $X=-220 $Y=62230
X1001 10 VIA2_C_CDNS_73 $T=490 84730 0 0 $X=-220 $Y=84330
X1002 10 VIA2_C_CDNS_73 $T=490 106830 0 0 $X=-220 $Y=106430
X1003 2 VIA2_C_CDNS_73 $T=1250 174755 0 0 $X=540 $Y=174355
X1004 2 VIA2_C_CDNS_73 $T=1250 190375 0 0 $X=540 $Y=189975
X1005 2 VIA2_C_CDNS_73 $T=1250 205995 0 0 $X=540 $Y=205595
X1006 13 VIA2_C_CDNS_73 $T=2270 63710 0 0 $X=1560 $Y=63310
X1007 13 VIA2_C_CDNS_73 $T=2270 85810 0 0 $X=1560 $Y=85410
X1008 13 VIA2_C_CDNS_73 $T=2270 107910 0 0 $X=1560 $Y=107510
X1009 10 VIA2_C_CDNS_73 $T=3030 175835 0 0 $X=2320 $Y=175435
X1010 10 VIA2_C_CDNS_73 $T=3030 191455 0 0 $X=2320 $Y=191055
X1011 10 VIA2_C_CDNS_73 $T=3030 207075 0 0 $X=2320 $Y=206675
X1012 12 VIA2_C_CDNS_73 $T=4050 64790 0 0 $X=3340 $Y=64390
X1013 12 VIA2_C_CDNS_73 $T=4050 86890 0 0 $X=3340 $Y=86490
X1014 12 VIA2_C_CDNS_73 $T=4050 108990 0 0 $X=3340 $Y=108590
X1015 12 VIA2_C_CDNS_73 $T=4810 176915 0 0 $X=4100 $Y=176515
X1016 12 VIA2_C_CDNS_73 $T=4810 192535 0 0 $X=4100 $Y=192135
X1017 12 VIA2_C_CDNS_73 $T=4810 208155 0 0 $X=4100 $Y=207755
X1018 15 VIA2_C_CDNS_73 $T=5830 65870 0 0 $X=5120 $Y=65470
X1019 15 VIA2_C_CDNS_73 $T=5830 87970 0 0 $X=5120 $Y=87570
X1020 15 VIA2_C_CDNS_73 $T=5830 110070 0 0 $X=5120 $Y=109670
X1021 14 VIA2_C_CDNS_73 $T=6590 177995 0 0 $X=5880 $Y=177595
X1022 14 VIA2_C_CDNS_73 $T=6590 193615 0 0 $X=5880 $Y=193215
X1023 14 VIA2_C_CDNS_73 $T=6590 209235 0 0 $X=5880 $Y=208835
X1024 14 VIA2_C_CDNS_73 $T=7610 66950 0 0 $X=6900 $Y=66550
X1025 14 VIA2_C_CDNS_73 $T=7610 89050 0 0 $X=6900 $Y=88650
X1026 14 VIA2_C_CDNS_73 $T=7610 111150 0 0 $X=6900 $Y=110750
X1027 16 VIA2_C_CDNS_73 $T=8370 179075 0 0 $X=7660 $Y=178675
X1028 16 VIA2_C_CDNS_73 $T=8370 194695 0 0 $X=7660 $Y=194295
X1029 16 VIA2_C_CDNS_73 $T=8370 210315 0 0 $X=7660 $Y=209915
X1030 17 VIA2_C_CDNS_73 $T=9390 68030 0 0 $X=8680 $Y=67630
X1031 17 VIA2_C_CDNS_73 $T=9390 90130 0 0 $X=8680 $Y=89730
X1032 17 VIA2_C_CDNS_73 $T=9390 112230 0 0 $X=8680 $Y=111830
X1033 18 VIA2_C_CDNS_73 $T=10150 180155 0 0 $X=9440 $Y=179755
X1034 18 VIA2_C_CDNS_73 $T=10150 195775 0 0 $X=9440 $Y=195375
X1035 18 VIA2_C_CDNS_73 $T=10150 211395 0 0 $X=9440 $Y=210995
X1036 16 VIA2_C_CDNS_73 $T=11170 69110 0 0 $X=10460 $Y=68710
X1037 16 VIA2_C_CDNS_73 $T=11170 91210 0 0 $X=10460 $Y=90810
X1038 16 VIA2_C_CDNS_73 $T=11170 113310 0 0 $X=10460 $Y=112910
X1039 20 VIA2_C_CDNS_73 $T=11930 173675 0 0 $X=11220 $Y=173275
X1040 20 VIA2_C_CDNS_73 $T=11930 189295 0 0 $X=11220 $Y=188895
X1041 20 VIA2_C_CDNS_73 $T=11930 204915 0 0 $X=11220 $Y=204515
X1042 19 VIA2_C_CDNS_73 $T=12950 70190 0 0 $X=12240 $Y=69790
X1043 19 VIA2_C_CDNS_73 $T=12950 92290 0 0 $X=12240 $Y=91890
X1044 19 VIA2_C_CDNS_73 $T=12950 114390 0 0 $X=12240 $Y=113990
X1045 18 VIA2_C_CDNS_73 $T=14730 71270 0 0 $X=14020 $Y=70870
X1046 18 VIA2_C_CDNS_73 $T=14730 93370 0 0 $X=14020 $Y=92970
X1047 18 VIA2_C_CDNS_73 $T=14730 115470 0 0 $X=14020 $Y=115070
X1048 20 VIA2_C_CDNS_73 $T=16510 60470 0 0 $X=15800 $Y=60070
X1049 20 VIA2_C_CDNS_73 $T=16510 82570 0 0 $X=15800 $Y=82170
X1050 20 VIA2_C_CDNS_73 $T=16510 104670 0 0 $X=15800 $Y=104270
X1051 3 VIA2_C_CDNS_73 $T=178930 58310 0 0 $X=178220 $Y=57910
X1052 3 VIA2_C_CDNS_73 $T=178930 80410 0 0 $X=178220 $Y=80010
X1053 3 VIA2_C_CDNS_73 $T=178930 102510 0 0 $X=178220 $Y=102110
X1054 11 VIA2_C_CDNS_73 $T=180710 61550 0 0 $X=180000 $Y=61150
X1055 11 VIA2_C_CDNS_73 $T=180710 83650 0 0 $X=180000 $Y=83250
X1056 11 VIA2_C_CDNS_73 $T=180710 105750 0 0 $X=180000 $Y=105350
X1057 10 VIA2_C_CDNS_73 $T=182490 62630 0 0 $X=181780 $Y=62230
X1058 10 VIA2_C_CDNS_73 $T=182490 84730 0 0 $X=181780 $Y=84330
X1059 10 VIA2_C_CDNS_73 $T=182490 106830 0 0 $X=181780 $Y=106430
X1060 13 VIA2_C_CDNS_73 $T=184270 63710 0 0 $X=183560 $Y=63310
X1061 13 VIA2_C_CDNS_73 $T=184270 85810 0 0 $X=183560 $Y=85410
X1062 13 VIA2_C_CDNS_73 $T=184270 107910 0 0 $X=183560 $Y=107510
X1063 20 VIA2_C_CDNS_73 $T=184390 173675 0 0 $X=183680 $Y=173275
X1064 20 VIA2_C_CDNS_73 $T=184390 189295 0 0 $X=183680 $Y=188895
X1065 20 VIA2_C_CDNS_73 $T=184390 204915 0 0 $X=183680 $Y=204515
X1066 12 VIA2_C_CDNS_73 $T=186050 64790 0 0 $X=185340 $Y=64390
X1067 12 VIA2_C_CDNS_73 $T=186050 86890 0 0 $X=185340 $Y=86490
X1068 12 VIA2_C_CDNS_73 $T=186050 108990 0 0 $X=185340 $Y=108590
X1069 18 VIA2_C_CDNS_73 $T=186170 180155 0 0 $X=185460 $Y=179755
X1070 18 VIA2_C_CDNS_73 $T=186170 195775 0 0 $X=185460 $Y=195375
X1071 18 VIA2_C_CDNS_73 $T=186170 211395 0 0 $X=185460 $Y=210995
X1072 15 VIA2_C_CDNS_73 $T=187830 65870 0 0 $X=187120 $Y=65470
X1073 15 VIA2_C_CDNS_73 $T=187830 87970 0 0 $X=187120 $Y=87570
X1074 15 VIA2_C_CDNS_73 $T=187830 110070 0 0 $X=187120 $Y=109670
X1075 16 VIA2_C_CDNS_73 $T=187950 179075 0 0 $X=187240 $Y=178675
X1076 16 VIA2_C_CDNS_73 $T=187950 194695 0 0 $X=187240 $Y=194295
X1077 16 VIA2_C_CDNS_73 $T=187950 210315 0 0 $X=187240 $Y=209915
X1078 14 VIA2_C_CDNS_73 $T=189610 66950 0 0 $X=188900 $Y=66550
X1079 14 VIA2_C_CDNS_73 $T=189610 89050 0 0 $X=188900 $Y=88650
X1080 14 VIA2_C_CDNS_73 $T=189610 111150 0 0 $X=188900 $Y=110750
X1081 14 VIA2_C_CDNS_73 $T=189730 177995 0 0 $X=189020 $Y=177595
X1082 14 VIA2_C_CDNS_73 $T=189730 193615 0 0 $X=189020 $Y=193215
X1083 14 VIA2_C_CDNS_73 $T=189730 209235 0 0 $X=189020 $Y=208835
X1084 17 VIA2_C_CDNS_73 $T=191390 68030 0 0 $X=190680 $Y=67630
X1085 17 VIA2_C_CDNS_73 $T=191390 90130 0 0 $X=190680 $Y=89730
X1086 17 VIA2_C_CDNS_73 $T=191390 112230 0 0 $X=190680 $Y=111830
X1087 12 VIA2_C_CDNS_73 $T=191510 176915 0 0 $X=190800 $Y=176515
X1088 12 VIA2_C_CDNS_73 $T=191510 192535 0 0 $X=190800 $Y=192135
X1089 12 VIA2_C_CDNS_73 $T=191510 208155 0 0 $X=190800 $Y=207755
X1090 16 VIA2_C_CDNS_73 $T=193170 69110 0 0 $X=192460 $Y=68710
X1091 16 VIA2_C_CDNS_73 $T=193170 91210 0 0 $X=192460 $Y=90810
X1092 16 VIA2_C_CDNS_73 $T=193170 113310 0 0 $X=192460 $Y=112910
X1093 10 VIA2_C_CDNS_73 $T=193290 175835 0 0 $X=192580 $Y=175435
X1094 10 VIA2_C_CDNS_73 $T=193290 191455 0 0 $X=192580 $Y=191055
X1095 10 VIA2_C_CDNS_73 $T=193290 207075 0 0 $X=192580 $Y=206675
X1096 19 VIA2_C_CDNS_73 $T=194950 70190 0 0 $X=194240 $Y=69790
X1097 19 VIA2_C_CDNS_73 $T=194950 92290 0 0 $X=194240 $Y=91890
X1098 19 VIA2_C_CDNS_73 $T=194950 114390 0 0 $X=194240 $Y=113990
X1099 2 VIA2_C_CDNS_73 $T=195070 174755 0 0 $X=194360 $Y=174355
X1100 2 VIA2_C_CDNS_73 $T=195070 190375 0 0 $X=194360 $Y=189975
X1101 2 VIA2_C_CDNS_73 $T=195070 205995 0 0 $X=194360 $Y=205595
X1102 18 VIA2_C_CDNS_73 $T=196730 71270 0 0 $X=196020 $Y=70870
X1103 18 VIA2_C_CDNS_73 $T=196730 93370 0 0 $X=196020 $Y=92970
X1104 18 VIA2_C_CDNS_73 $T=196730 115470 0 0 $X=196020 $Y=115070
X1105 20 VIA2_C_CDNS_73 $T=198510 60470 0 0 $X=197800 $Y=60070
X1106 20 VIA2_C_CDNS_73 $T=198510 82570 0 0 $X=197800 $Y=82170
X1107 20 VIA2_C_CDNS_73 $T=198510 104670 0 0 $X=197800 $Y=104270
X1108 2 VIA2_C_CDNS_73 $T=200290 59390 0 0 $X=199580 $Y=58990
X1109 2 VIA2_C_CDNS_73 $T=200290 81490 0 0 $X=199580 $Y=81090
X1110 2 VIA2_C_CDNS_73 $T=200290 103590 0 0 $X=199580 $Y=103190
X1111 20 P1_C_CDNS_74 $T=55490 212655 0 0 $X=54780 $Y=212445
X1112 20 P1_C_CDNS_74 $T=60510 165795 0 0 $X=59800 $Y=165585
X1113 3 P1_C_CDNS_74 $T=100230 50430 0 0 $X=99520 $Y=50220
X1114 20 P1_C_CDNS_74 $T=100670 212655 0 0 $X=99960 $Y=212445
X1115 2 VIA2_C_CDNS_76 $T=-4850 25780 0 0 $X=-5600 $Y=25550
X1116 2 VIA2_C_CDNS_76 $T=-4850 148000 0 0 $X=-5600 $Y=147770
X1117 2 VIA2_C_CDNS_76 $T=1250 151825 0 0 $X=500 $Y=151595
X1118 2 VIA2_C_CDNS_76 $T=1250 233245 0 0 $X=500 $Y=233015
X1119 2 VIA2_C_CDNS_76 $T=195070 151825 0 0 $X=194320 $Y=151595
X1120 2 VIA2_C_CDNS_76 $T=195070 233245 0 0 $X=194320 $Y=233015
X1121 2 VIA2_C_CDNS_76 $T=200290 25780 0 0 $X=199540 $Y=25550
X1122 2 VIA2_C_CDNS_76 $T=200290 148000 0 0 $X=199540 $Y=147770
X1123 2 VIA1_C_CDNS_77 $T=-4850 25780 0 0 $X=-5600 $Y=25550
X1124 2 VIA1_C_CDNS_77 $T=-4850 148000 0 0 $X=-5600 $Y=147770
X1125 2 VIA1_C_CDNS_77 $T=1250 151825 0 0 $X=500 $Y=151595
X1126 2 VIA1_C_CDNS_77 $T=1250 233245 0 0 $X=500 $Y=233015
X1127 2 VIA1_C_CDNS_77 $T=195070 151825 0 0 $X=194320 $Y=151595
X1128 2 VIA1_C_CDNS_77 $T=195070 233245 0 0 $X=194320 $Y=233015
X1129 2 VIA1_C_CDNS_77 $T=200290 25780 0 0 $X=199540 $Y=25550
X1130 2 VIA1_C_CDNS_77 $T=200290 148000 0 0 $X=199540 $Y=147770
X1131 2 VIA1_C_CDNS_78 $T=-6530 27460 0 0 $X=-6760 $Y=26710
X1132 2 VIA1_C_CDNS_78 $T=-6530 146320 0 0 $X=-6760 $Y=145570
X1133 2 VIA1_C_CDNS_78 $T=-430 153505 0 0 $X=-660 $Y=152755
X1134 2 VIA1_C_CDNS_78 $T=-430 231565 0 0 $X=-660 $Y=230815
X1135 2 VIA1_C_CDNS_78 $T=196750 153505 0 0 $X=196520 $Y=152755
X1136 2 VIA1_C_CDNS_78 $T=196750 231565 0 0 $X=196520 $Y=230815
X1137 2 VIA1_C_CDNS_78 $T=201970 27460 0 0 $X=201740 $Y=26710
X1138 2 VIA1_C_CDNS_78 $T=201970 146320 0 0 $X=201740 $Y=145570
X1139 11 4 5 2 1 pe3_CDNS_79 $T=76900 12835 1 0 $X=75390 $Y=9805
X1140 13 6 5 2 1 pe3_CDNS_79 $T=86100 12835 1 0 $X=84590 $Y=9805
X1141 15 7 5 2 1 pe3_CDNS_79 $T=95300 12835 1 0 $X=93790 $Y=9805
X1142 17 8 5 2 1 pe3_CDNS_79 $T=104500 12835 1 0 $X=102990 $Y=9805
X1143 19 9 5 2 1 pe3_CDNS_79 $T=113700 12835 1 0 $X=112190 $Y=9805
X1144 2 2 2 2 1 pe3_CDNS_80 $T=14330 166105 0 0 $X=12820 $Y=165075
X1145 2 2 2 2 1 pe3_CDNS_80 $T=14330 181725 0 0 $X=12820 $Y=180695
X1146 2 2 2 2 1 pe3_CDNS_80 $T=14330 197345 0 0 $X=12820 $Y=196315
X1147 2 2 2 2 1 pe3_CDNS_80 $T=14330 212965 0 0 $X=12820 $Y=211935
X1148 18 3 19 2 1 pe3_CDNS_80 $T=18910 50740 0 0 $X=17400 $Y=49710
X1149 16 3 17 2 1 pe3_CDNS_80 $T=18910 72840 0 0 $X=17400 $Y=71810
X1150 16 3 17 2 1 pe3_CDNS_80 $T=18910 94940 0 0 $X=17400 $Y=93910
X1151 18 3 19 2 1 pe3_CDNS_80 $T=18910 117040 0 0 $X=17400 $Y=116010
X1152 2 20 18 2 1 pe3_CDNS_80 $T=19350 166105 0 0 $X=17840 $Y=165075
X1153 2 20 16 2 1 pe3_CDNS_80 $T=19350 181725 0 0 $X=17840 $Y=180695
X1154 2 20 16 2 1 pe3_CDNS_80 $T=19350 197345 0 0 $X=17840 $Y=196315
X1155 2 20 18 2 1 pe3_CDNS_80 $T=19350 212965 0 0 $X=17840 $Y=211935
X1156 18 3 19 2 1 pe3_CDNS_80 $T=23930 50740 0 0 $X=22420 $Y=49710
X1157 18 3 19 2 1 pe3_CDNS_80 $T=23930 72840 0 0 $X=22420 $Y=71810
X1158 18 3 19 2 1 pe3_CDNS_80 $T=23930 94940 0 0 $X=22420 $Y=93910
X1159 18 3 19 2 1 pe3_CDNS_80 $T=23930 117040 0 0 $X=22420 $Y=116010
X1160 2 20 18 2 1 pe3_CDNS_80 $T=24370 166105 0 0 $X=22860 $Y=165075
X1161 2 20 18 2 1 pe3_CDNS_80 $T=24370 181725 0 0 $X=22860 $Y=180695
X1162 2 20 18 2 1 pe3_CDNS_80 $T=24370 197345 0 0 $X=22860 $Y=196315
X1163 2 20 18 2 1 pe3_CDNS_80 $T=24370 212965 0 0 $X=22860 $Y=211935
X1164 18 3 19 2 1 pe3_CDNS_80 $T=28950 50740 0 0 $X=27440 $Y=49710
X1165 16 3 17 2 1 pe3_CDNS_80 $T=28950 72840 0 0 $X=27440 $Y=71810
X1166 16 3 17 2 1 pe3_CDNS_80 $T=28950 94940 0 0 $X=27440 $Y=93910
X1167 18 3 19 2 1 pe3_CDNS_80 $T=28950 117040 0 0 $X=27440 $Y=116010
X1168 2 20 18 2 1 pe3_CDNS_80 $T=29390 166105 0 0 $X=27880 $Y=165075
X1169 2 20 16 2 1 pe3_CDNS_80 $T=29390 181725 0 0 $X=27880 $Y=180695
X1170 2 20 16 2 1 pe3_CDNS_80 $T=29390 197345 0 0 $X=27880 $Y=196315
X1171 2 20 18 2 1 pe3_CDNS_80 $T=29390 212965 0 0 $X=27880 $Y=211935
X1172 18 3 19 2 1 pe3_CDNS_80 $T=33970 50740 0 0 $X=32460 $Y=49710
X1173 18 3 19 2 1 pe3_CDNS_80 $T=33970 72840 0 0 $X=32460 $Y=71810
X1174 18 3 19 2 1 pe3_CDNS_80 $T=33970 94940 0 0 $X=32460 $Y=93910
X1175 18 3 19 2 1 pe3_CDNS_80 $T=33970 117040 0 0 $X=32460 $Y=116010
X1176 2 20 18 2 1 pe3_CDNS_80 $T=34410 166105 0 0 $X=32900 $Y=165075
X1177 2 20 18 2 1 pe3_CDNS_80 $T=34410 181725 0 0 $X=32900 $Y=180695
X1178 2 20 18 2 1 pe3_CDNS_80 $T=34410 197345 0 0 $X=32900 $Y=196315
X1179 2 20 18 2 1 pe3_CDNS_80 $T=34410 212965 0 0 $X=32900 $Y=211935
X1180 18 3 19 2 1 pe3_CDNS_80 $T=38990 50740 0 0 $X=37480 $Y=49710
X1181 16 3 17 2 1 pe3_CDNS_80 $T=38990 72840 0 0 $X=37480 $Y=71810
X1182 16 3 17 2 1 pe3_CDNS_80 $T=38990 94940 0 0 $X=37480 $Y=93910
X1183 18 3 19 2 1 pe3_CDNS_80 $T=38990 117040 0 0 $X=37480 $Y=116010
X1184 2 20 18 2 1 pe3_CDNS_80 $T=39430 166105 0 0 $X=37920 $Y=165075
X1185 2 20 16 2 1 pe3_CDNS_80 $T=39430 181725 0 0 $X=37920 $Y=180695
X1186 2 20 16 2 1 pe3_CDNS_80 $T=39430 197345 0 0 $X=37920 $Y=196315
X1187 2 20 18 2 1 pe3_CDNS_80 $T=39430 212965 0 0 $X=37920 $Y=211935
X1188 18 3 19 2 1 pe3_CDNS_80 $T=44010 50740 0 0 $X=42500 $Y=49710
X1189 18 3 19 2 1 pe3_CDNS_80 $T=44010 72840 0 0 $X=42500 $Y=71810
X1190 18 3 19 2 1 pe3_CDNS_80 $T=44010 94940 0 0 $X=42500 $Y=93910
X1191 18 3 19 2 1 pe3_CDNS_80 $T=44010 117040 0 0 $X=42500 $Y=116010
X1192 2 20 18 2 1 pe3_CDNS_80 $T=44450 166105 0 0 $X=42940 $Y=165075
X1193 2 20 18 2 1 pe3_CDNS_80 $T=44450 181725 0 0 $X=42940 $Y=180695
X1194 2 20 18 2 1 pe3_CDNS_80 $T=44450 197345 0 0 $X=42940 $Y=196315
X1195 2 20 18 2 1 pe3_CDNS_80 $T=44450 212965 0 0 $X=42940 $Y=211935
X1196 18 3 19 2 1 pe3_CDNS_80 $T=49030 50740 0 0 $X=47520 $Y=49710
X1197 16 3 17 2 1 pe3_CDNS_80 $T=49030 72840 0 0 $X=47520 $Y=71810
X1198 16 3 17 2 1 pe3_CDNS_80 $T=49030 94940 0 0 $X=47520 $Y=93910
X1199 18 3 19 2 1 pe3_CDNS_80 $T=49030 117040 0 0 $X=47520 $Y=116010
X1200 2 20 18 2 1 pe3_CDNS_80 $T=49470 166105 0 0 $X=47960 $Y=165075
X1201 2 20 16 2 1 pe3_CDNS_80 $T=49470 181725 0 0 $X=47960 $Y=180695
X1202 2 20 16 2 1 pe3_CDNS_80 $T=49470 197345 0 0 $X=47960 $Y=196315
X1203 2 20 18 2 1 pe3_CDNS_80 $T=49470 212965 0 0 $X=47960 $Y=211935
X1204 18 3 19 2 1 pe3_CDNS_80 $T=54050 50740 0 0 $X=52540 $Y=49710
X1205 14 3 15 2 1 pe3_CDNS_80 $T=54050 72840 0 0 $X=52540 $Y=71810
X1206 14 3 15 2 1 pe3_CDNS_80 $T=54050 94940 0 0 $X=52540 $Y=93910
X1207 18 3 19 2 1 pe3_CDNS_80 $T=54050 117040 0 0 $X=52540 $Y=116010
X1208 2 20 18 2 1 pe3_CDNS_80 $T=54490 166105 0 0 $X=52980 $Y=165075
X1209 2 20 14 2 1 pe3_CDNS_80 $T=54490 181725 0 0 $X=52980 $Y=180695
X1210 2 20 14 2 1 pe3_CDNS_80 $T=54490 197345 0 0 $X=52980 $Y=196315
X1211 2 20 18 2 1 pe3_CDNS_80 $T=54490 212965 0 0 $X=52980 $Y=211935
X1212 18 3 19 2 1 pe3_CDNS_80 $T=59070 50740 0 0 $X=57560 $Y=49710
X1213 16 3 17 2 1 pe3_CDNS_80 $T=59070 72840 0 0 $X=57560 $Y=71810
X1214 16 3 17 2 1 pe3_CDNS_80 $T=59070 94940 0 0 $X=57560 $Y=93910
X1215 18 3 19 2 1 pe3_CDNS_80 $T=59070 117040 0 0 $X=57560 $Y=116010
X1216 2 20 18 2 1 pe3_CDNS_80 $T=59510 166105 0 0 $X=58000 $Y=165075
X1217 2 20 16 2 1 pe3_CDNS_80 $T=59510 181725 0 0 $X=58000 $Y=180695
X1218 2 20 16 2 1 pe3_CDNS_80 $T=59510 197345 0 0 $X=58000 $Y=196315
X1219 2 20 18 2 1 pe3_CDNS_80 $T=59510 212965 0 0 $X=58000 $Y=211935
X1220 18 3 19 2 1 pe3_CDNS_80 $T=64090 50740 0 0 $X=62580 $Y=49710
X1221 14 3 15 2 1 pe3_CDNS_80 $T=64090 72840 0 0 $X=62580 $Y=71810
X1222 14 3 15 2 1 pe3_CDNS_80 $T=64090 94940 0 0 $X=62580 $Y=93910
X1223 18 3 19 2 1 pe3_CDNS_80 $T=64090 117040 0 0 $X=62580 $Y=116010
X1224 2 20 18 2 1 pe3_CDNS_80 $T=64530 166105 0 0 $X=63020 $Y=165075
X1225 2 20 14 2 1 pe3_CDNS_80 $T=64530 181725 0 0 $X=63020 $Y=180695
X1226 2 20 14 2 1 pe3_CDNS_80 $T=64530 197345 0 0 $X=63020 $Y=196315
X1227 2 20 18 2 1 pe3_CDNS_80 $T=64530 212965 0 0 $X=63020 $Y=211935
X1228 18 3 19 2 1 pe3_CDNS_80 $T=69110 50740 0 0 $X=67600 $Y=49710
X1229 16 3 17 2 1 pe3_CDNS_80 $T=69110 72840 0 0 $X=67600 $Y=71810
X1230 16 3 17 2 1 pe3_CDNS_80 $T=69110 94940 0 0 $X=67600 $Y=93910
X1231 18 3 19 2 1 pe3_CDNS_80 $T=69110 117040 0 0 $X=67600 $Y=116010
X1232 2 20 18 2 1 pe3_CDNS_80 $T=69550 166105 0 0 $X=68040 $Y=165075
X1233 2 20 16 2 1 pe3_CDNS_80 $T=69550 181725 0 0 $X=68040 $Y=180695
X1234 2 20 16 2 1 pe3_CDNS_80 $T=69550 197345 0 0 $X=68040 $Y=196315
X1235 2 20 18 2 1 pe3_CDNS_80 $T=69550 212965 0 0 $X=68040 $Y=211935
X1236 18 3 19 2 1 pe3_CDNS_80 $T=74130 50740 0 0 $X=72620 $Y=49710
X1237 14 3 15 2 1 pe3_CDNS_80 $T=74130 72840 0 0 $X=72620 $Y=71810
X1238 14 3 15 2 1 pe3_CDNS_80 $T=74130 94940 0 0 $X=72620 $Y=93910
X1239 18 3 19 2 1 pe3_CDNS_80 $T=74130 117040 0 0 $X=72620 $Y=116010
X1240 2 20 18 2 1 pe3_CDNS_80 $T=74570 166105 0 0 $X=73060 $Y=165075
X1241 2 20 14 2 1 pe3_CDNS_80 $T=74570 181725 0 0 $X=73060 $Y=180695
X1242 2 20 14 2 1 pe3_CDNS_80 $T=74570 197345 0 0 $X=73060 $Y=196315
X1243 2 20 18 2 1 pe3_CDNS_80 $T=74570 212965 0 0 $X=73060 $Y=211935
X1244 18 3 19 2 1 pe3_CDNS_80 $T=79150 50740 0 0 $X=77640 $Y=49710
X1245 16 3 17 2 1 pe3_CDNS_80 $T=79150 72840 0 0 $X=77640 $Y=71810
X1246 16 3 17 2 1 pe3_CDNS_80 $T=79150 94940 0 0 $X=77640 $Y=93910
X1247 18 3 19 2 1 pe3_CDNS_80 $T=79150 117040 0 0 $X=77640 $Y=116010
X1248 2 20 18 2 1 pe3_CDNS_80 $T=79590 166105 0 0 $X=78080 $Y=165075
X1249 2 20 16 2 1 pe3_CDNS_80 $T=79590 181725 0 0 $X=78080 $Y=180695
X1250 2 20 16 2 1 pe3_CDNS_80 $T=79590 197345 0 0 $X=78080 $Y=196315
X1251 2 20 18 2 1 pe3_CDNS_80 $T=79590 212965 0 0 $X=78080 $Y=211935
X1252 16 3 17 2 1 pe3_CDNS_80 $T=84170 50740 0 0 $X=82660 $Y=49710
X1253 14 3 15 2 1 pe3_CDNS_80 $T=84170 72840 0 0 $X=82660 $Y=71810
X1254 14 3 15 2 1 pe3_CDNS_80 $T=84170 94940 0 0 $X=82660 $Y=93910
X1255 16 3 17 2 1 pe3_CDNS_80 $T=84170 117040 0 0 $X=82660 $Y=116010
X1256 2 20 16 2 1 pe3_CDNS_80 $T=84610 166105 0 0 $X=83100 $Y=165075
X1257 2 20 14 2 1 pe3_CDNS_80 $T=84610 181725 0 0 $X=83100 $Y=180695
X1258 2 20 14 2 1 pe3_CDNS_80 $T=84610 197345 0 0 $X=83100 $Y=196315
X1259 2 20 16 2 1 pe3_CDNS_80 $T=84610 212965 0 0 $X=83100 $Y=211935
X1260 10 3 11 2 1 pe3_CDNS_80 $T=89190 50740 0 0 $X=87680 $Y=49710
X1261 12 3 13 2 1 pe3_CDNS_80 $T=89190 72840 0 0 $X=87680 $Y=71810
X1262 12 3 13 2 1 pe3_CDNS_80 $T=89190 94940 0 0 $X=87680 $Y=93910
X1263 10 3 11 2 1 pe3_CDNS_80 $T=89190 117040 0 0 $X=87680 $Y=116010
X1264 2 20 10 2 1 pe3_CDNS_80 $T=89630 166105 0 0 $X=88120 $Y=165075
X1265 2 20 12 2 1 pe3_CDNS_80 $T=89630 181725 0 0 $X=88120 $Y=180695
X1266 2 20 12 2 1 pe3_CDNS_80 $T=89630 197345 0 0 $X=88120 $Y=196315
X1267 2 20 10 2 1 pe3_CDNS_80 $T=89630 212965 0 0 $X=88120 $Y=211935
X1268 12 3 13 2 1 pe3_CDNS_80 $T=94210 50740 0 0 $X=92700 $Y=49710
X1269 20 3 3 2 1 pe3_CDNS_80 $T=94210 72840 0 0 $X=92700 $Y=71810
X1270 20 3 3 2 1 pe3_CDNS_80 $T=94210 94940 0 0 $X=92700 $Y=93910
X1271 12 3 13 2 1 pe3_CDNS_80 $T=94210 117040 0 0 $X=92700 $Y=116010
X1272 2 20 12 2 1 pe3_CDNS_80 $T=94650 166105 0 0 $X=93140 $Y=165075
X1273 2 20 20 2 1 pe3_CDNS_80 $T=94650 181725 0 0 $X=93140 $Y=180695
X1274 2 20 20 2 1 pe3_CDNS_80 $T=94650 197345 0 0 $X=93140 $Y=196315
X1275 2 20 12 2 1 pe3_CDNS_80 $T=94650 212965 0 0 $X=93140 $Y=211935
X1276 12 3 13 2 1 pe3_CDNS_80 $T=99230 50740 0 0 $X=97720 $Y=49710
X1277 20 3 3 2 1 pe3_CDNS_80 $T=99230 72840 0 0 $X=97720 $Y=71810
X1278 20 3 3 2 1 pe3_CDNS_80 $T=99230 94940 0 0 $X=97720 $Y=93910
X1279 12 3 13 2 1 pe3_CDNS_80 $T=99230 117040 0 0 $X=97720 $Y=116010
X1280 2 20 12 2 1 pe3_CDNS_80 $T=99670 166105 0 0 $X=98160 $Y=165075
X1281 2 20 20 2 1 pe3_CDNS_80 $T=99670 181725 0 0 $X=98160 $Y=180695
X1282 2 20 20 2 1 pe3_CDNS_80 $T=99670 197345 0 0 $X=98160 $Y=196315
X1283 2 20 12 2 1 pe3_CDNS_80 $T=99670 212965 0 0 $X=98160 $Y=211935
X1284 10 3 11 2 1 pe3_CDNS_80 $T=106250 50740 1 180 $X=102740 $Y=49710
X1285 12 3 13 2 1 pe3_CDNS_80 $T=106250 72840 1 180 $X=102740 $Y=71810
X1286 12 3 13 2 1 pe3_CDNS_80 $T=106250 94940 1 180 $X=102740 $Y=93910
X1287 10 3 11 2 1 pe3_CDNS_80 $T=106250 117040 1 180 $X=102740 $Y=116010
X1288 2 20 10 2 1 pe3_CDNS_80 $T=106690 166105 1 180 $X=103180 $Y=165075
X1289 2 20 12 2 1 pe3_CDNS_80 $T=106690 181725 1 180 $X=103180 $Y=180695
X1290 2 20 12 2 1 pe3_CDNS_80 $T=106690 197345 1 180 $X=103180 $Y=196315
X1291 2 20 10 2 1 pe3_CDNS_80 $T=106690 212965 1 180 $X=103180 $Y=211935
X1292 2 20 16 2 1 pe3_CDNS_80 $T=111710 166105 1 180 $X=108200 $Y=165075
X1293 2 20 14 2 1 pe3_CDNS_80 $T=111710 181725 1 180 $X=108200 $Y=180695
X1294 2 20 14 2 1 pe3_CDNS_80 $T=111710 197345 1 180 $X=108200 $Y=196315
X1295 2 20 16 2 1 pe3_CDNS_80 $T=111710 212965 1 180 $X=108200 $Y=211935
X1296 2 20 18 2 1 pe3_CDNS_80 $T=134810 166105 0 0 $X=133300 $Y=165075
X1297 2 20 16 2 1 pe3_CDNS_80 $T=134810 181725 0 0 $X=133300 $Y=180695
X1298 2 20 16 2 1 pe3_CDNS_80 $T=134810 197345 0 0 $X=133300 $Y=196315
X1299 2 20 18 2 1 pe3_CDNS_80 $T=134810 212965 0 0 $X=133300 $Y=211935
X1300 2 20 18 2 1 pe3_CDNS_80 $T=139830 166105 0 0 $X=138320 $Y=165075
X1301 2 20 14 2 1 pe3_CDNS_80 $T=139830 181725 0 0 $X=138320 $Y=180695
X1302 2 20 14 2 1 pe3_CDNS_80 $T=139830 197345 0 0 $X=138320 $Y=196315
X1303 2 20 18 2 1 pe3_CDNS_80 $T=139830 212965 0 0 $X=138320 $Y=211935
X1304 2 20 18 2 1 pe3_CDNS_80 $T=146850 166105 1 180 $X=143340 $Y=165075
X1305 2 20 16 2 1 pe3_CDNS_80 $T=146850 181725 1 180 $X=143340 $Y=180695
X1306 2 20 16 2 1 pe3_CDNS_80 $T=146850 197345 1 180 $X=143340 $Y=196315
X1307 2 20 18 2 1 pe3_CDNS_80 $T=146850 212965 1 180 $X=143340 $Y=211935
X1308 2 20 18 2 1 pe3_CDNS_80 $T=151870 166105 1 180 $X=148360 $Y=165075
X1309 2 20 18 2 1 pe3_CDNS_80 $T=151870 181725 1 180 $X=148360 $Y=180695
X1310 2 20 18 2 1 pe3_CDNS_80 $T=151870 197345 1 180 $X=148360 $Y=196315
X1311 2 20 18 2 1 pe3_CDNS_80 $T=151870 212965 1 180 $X=148360 $Y=211935
X1312 18 3 19 2 1 pe3_CDNS_80 $T=171510 50740 1 180 $X=168000 $Y=49710
X1313 18 3 19 2 1 pe3_CDNS_80 $T=171510 72840 1 180 $X=168000 $Y=71810
X1314 18 3 19 2 1 pe3_CDNS_80 $T=171510 94940 1 180 $X=168000 $Y=93910
X1315 18 3 19 2 1 pe3_CDNS_80 $T=171510 117040 1 180 $X=168000 $Y=116010
X1316 18 3 19 2 1 pe3_CDNS_80 $T=176530 50740 1 180 $X=173020 $Y=49710
X1317 16 3 17 2 1 pe3_CDNS_80 $T=176530 72840 1 180 $X=173020 $Y=71810
X1318 16 3 17 2 1 pe3_CDNS_80 $T=176530 94940 1 180 $X=173020 $Y=93910
X1319 18 3 19 2 1 pe3_CDNS_80 $T=176530 117040 1 180 $X=173020 $Y=116010
X1320 2 20 18 2 1 pe3_CDNS_80 $T=176970 166105 1 180 $X=173460 $Y=165075
X1321 2 20 16 2 1 pe3_CDNS_80 $T=176970 181725 1 180 $X=173460 $Y=180695
X1322 2 20 16 2 1 pe3_CDNS_80 $T=176970 197345 1 180 $X=173460 $Y=196315
X1323 2 20 18 2 1 pe3_CDNS_80 $T=176970 212965 1 180 $X=173460 $Y=211935
X1324 2 2 2 2 1 pe3_CDNS_80 $T=179990 166105 0 0 $X=178480 $Y=165075
X1325 2 2 2 2 1 pe3_CDNS_80 $T=179990 181725 0 0 $X=178480 $Y=180695
X1326 2 2 2 2 1 pe3_CDNS_80 $T=179990 197345 0 0 $X=178480 $Y=196315
X1327 2 2 2 2 1 pe3_CDNS_80 $T=179990 212965 0 0 $X=178480 $Y=211935
X1328 3 18 19 16 17 18 19 2 1 MASCO__A45 $T=107760 49710 0 0 $X=107760 $Y=49710
X1329 3 16 17 14 15 14 15 2 1 MASCO__A45 $T=107760 71810 0 0 $X=107760 $Y=71810
X1330 3 16 17 14 15 14 15 2 1 MASCO__A45 $T=107760 93910 0 0 $X=107760 $Y=93910
X1331 3 18 19 16 17 18 19 2 1 MASCO__A45 $T=107760 116010 0 0 $X=107760 $Y=116010
X1332 20 2 18 2 18 2 18 2 1 MASCO__A45 $T=113220 165075 0 0 $X=113220 $Y=165075
X1333 20 2 14 2 16 2 16 2 1 MASCO__A45 $T=113220 180695 0 0 $X=113220 $Y=180695
X1334 20 2 14 2 16 2 16 2 1 MASCO__A45 $T=113220 196315 0 0 $X=113220 $Y=196315
X1335 20 2 18 2 18 2 18 2 1 MASCO__A45 $T=113220 211935 0 0 $X=113220 $Y=211935
X1336 3 18 19 18 19 18 19 2 1 MASCO__A45 $T=127840 49710 0 0 $X=127840 $Y=49710
X1337 3 16 17 14 15 14 15 2 1 MASCO__A45 $T=127840 71810 0 0 $X=127840 $Y=71810
X1338 3 16 17 14 15 14 15 2 1 MASCO__A45 $T=127840 93910 0 0 $X=127840 $Y=93910
X1339 3 18 19 18 19 18 19 2 1 MASCO__A45 $T=127840 116010 0 0 $X=127840 $Y=116010
X1340 3 18 19 18 19 18 19 2 1 MASCO__A45 $T=147920 49710 0 0 $X=147920 $Y=49710
X1341 3 16 17 18 19 18 19 2 1 MASCO__A45 $T=147920 71810 0 0 $X=147920 $Y=71810
X1342 3 16 17 18 19 18 19 2 1 MASCO__A45 $T=147920 93910 0 0 $X=147920 $Y=93910
X1343 3 18 19 18 19 18 19 2 1 MASCO__A45 $T=147920 116010 0 0 $X=147920 $Y=116010
X1344 20 2 18 2 18 2 18 2 1 MASCO__A45 $T=153380 165075 0 0 $X=153380 $Y=165075
X1345 20 2 18 2 16 2 16 2 1 MASCO__A45 $T=153380 180695 0 0 $X=153380 $Y=180695
X1346 20 2 18 2 16 2 16 2 1 MASCO__A45 $T=153380 196315 0 0 $X=153380 $Y=196315
X1347 20 2 18 2 18 2 18 2 1 MASCO__A45 $T=153380 211935 0 0 $X=153380 $Y=211935
D0 1 2 p_dnw AREA=2.0589e-08 PJ=0.00066488 perimeter=0.00066488 $X=-6960 $Y=25350 $dt=156
D1 1 2 p_dnw AREA=1.0792e-08 PJ=0.00056064 perimeter=0.00056064 $X=-860 $Y=151395 $dt=156
D2 1 2 p_dnw AREA=1.20791e-09 PJ=0.00017132 perimeter=0.00017132 $X=66490 $Y=905 $dt=156
D3 1 2 p_dnw3 AREA=1.37568e-09 PJ=0 perimeter=0 $X=12820 $Y=165075 $dt=243
D4 1 2 p_dnw3 AREA=1.37568e-09 PJ=0 perimeter=0 $X=12820 $Y=180695 $dt=243
D5 1 2 p_dnw3 AREA=1.37568e-09 PJ=0 perimeter=0 $X=12820 $Y=196315 $dt=243
D6 1 2 p_dnw3 AREA=1.37568e-09 PJ=0 perimeter=0 $X=12820 $Y=211935 $dt=243
D7 1 2 p_dnw3 AREA=1.29476e-09 PJ=0 perimeter=0 $X=17400 $Y=49710 $dt=243
D8 1 2 p_dnw3 AREA=1.29476e-09 PJ=0 perimeter=0 $X=17400 $Y=71810 $dt=243
D9 1 2 p_dnw3 AREA=1.29476e-09 PJ=0 perimeter=0 $X=17400 $Y=93910 $dt=243
D10 1 2 p_dnw3 AREA=1.29476e-09 PJ=0 perimeter=0 $X=17400 $Y=116010 $dt=243
D11 1 2 p_dnw3 AREA=1.8676e-10 PJ=0 perimeter=0 $X=75390 $Y=9805 $dt=243
.ends Idac_5bit_ST_V3

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_81                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_81 1 2
** N=2 EP=2 FDC=0
.ends VIA3_C_CDNS_81

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_82                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_82 1 2
** N=2 EP=2 FDC=0
.ends VIA2_C_CDNS_82

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_84                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_84 1 2
** N=2 EP=2 FDC=0
.ends VIA3_C_CDNS_84

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_85                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_85 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_85

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_88                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_88 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_88

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_89                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_89 1 2
** N=2 EP=2 FDC=0
.ends VIA2_C_CDNS_89

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_90                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_90 1 2
** N=2 EP=2 FDC=0
.ends VIA3_C_CDNS_90

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_91                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_91 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_91

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_92                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_92 1 2
** N=2 EP=2 FDC=0
.ends VIA2_C_CDNS_92

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_93                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_93 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_93

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_94                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_94 1 2
** N=2 EP=2 FDC=0
.ends VIA2_C_CDNS_94

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_95                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_95 1 2
** N=2 EP=2 FDC=0
.ends VIA3_C_CDNS_95

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_96                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_96 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_96

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_97                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_97 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_97

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_98                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_98 1 2
** N=2 EP=2 FDC=0
.ends VIA2_C_CDNS_98

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_99                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_99 1 2
** N=2 EP=2 FDC=0
.ends VIA3_C_CDNS_99

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_100                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_100 1
** N=1 EP=1 FDC=0
.ends VIA3_C_CDNS_100

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_101                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_101 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_101

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_102                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_102 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_102

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_106                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_106 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_106

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_109                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_109 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_109

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_110                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_110 1 2
** N=2 EP=2 FDC=0
.ends VIA2_C_CDNS_110

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_112                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_112 1
** N=1 EP=1 FDC=0
.ends VIA3_C_CDNS_112

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_115                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_115 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_115

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_116                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_116 1 2
** N=2 EP=2 FDC=0
.ends VIA2_C_CDNS_116

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_117                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_117 1 2
** N=2 EP=2 FDC=0
.ends VIA2_C_CDNS_117

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_118                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_118 1 2
** N=2 EP=2 FDC=0
.ends VIA3_C_CDNS_118

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_119                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_119 1 2
** N=2 EP=2 FDC=0
.ends VIA2_C_CDNS_119

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_120                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_120 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_120

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_121                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_121 1 2
** N=2 EP=2 FDC=0
.ends VIA3_C_CDNS_121

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_124                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_124 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_124

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: nedia_bjt_CDNS_125                              *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt nedia_bjt_CDNS_125 1 2 3 4
** N=4 EP=4 FDC=1
X0 2 4 3 1 LDDN w=8e-05 l=1.25e-06 adio=1.41512e-09 pdio=0.00016535 extlay=1 $[nedia_bjt] $X=-680 $Y=-4850 $dt=67
.ends nedia_bjt_CDNS_125

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: nedia_bjt_CDNS_126                              *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt nedia_bjt_CDNS_126 1 2 3 4
** N=4 EP=4 FDC=1
X0 2 3 4 1 LDDN w=3.5e-05 l=1.25e-06 adio=9.21466e-10 pdio=0.00012035 extlay=1 $[nedia_bjt] $X=-680 $Y=-4850 $dt=67
.ends nedia_bjt_CDNS_126

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: nedia_bjt_CDNS_127                              *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt nedia_bjt_CDNS_127 1 2 3 4
** N=4 EP=4 FDC=5
X0 2 3 4 1 LDDN w=6e-05 l=1.25e-06 adio=7.93969e-10 pdio=4.811e-05 extlay=1 $[nedia_bjt] $X=-680 $Y=-4850 $dt=67
X1 2 3 4 1 LDDN w=6e-05 l=1.25e-06 adio=7.93969e-10 pdio=4.811e-05 extlay=1 $[nedia_bjt] $X=11220 $Y=-4850 $dt=67
X2 2 3 4 1 LDDN w=6e-05 l=1.25e-06 adio=7.93969e-10 pdio=4.811e-05 extlay=1 $[nedia_bjt] $X=23120 $Y=-4850 $dt=67
X3 2 3 4 1 LDDN w=6e-05 l=1.25e-06 adio=7.93969e-10 pdio=4.811e-05 extlay=1 $[nedia_bjt] $X=35020 $Y=-4850 $dt=67
X4 2 3 4 1 LDDN w=6e-05 l=1.25e-06 adio=7.93969e-10 pdio=4.811e-05 extlay=1 $[nedia_bjt] $X=46920 $Y=-4850 $dt=67
.ends nedia_bjt_CDNS_127

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: LSHVT18U3VX2                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt LSHVT18U3VX2 1 2 3 4 5
** N=10 EP=5 FDC=13
M0 8 4 2 2 ne3 L=3.5e-07 W=4.2e-07 AD=2.016e-13 AS=3.654e-13 PD=1.8e-06 PS=2.58e-06 $X=660 $Y=660 $dt=83
M1 2 8 6 2 ne3 L=3.5e-07 W=1.31e-06 AD=3.537e-13 AS=6.187e-13 PD=1.85e-06 PS=3.61e-06 $X=2345 $Y=660 $dt=83
M2 7 4 2 2 ne3 L=3.5e-07 W=1.31e-06 AD=6.288e-13 AS=3.537e-13 PD=3.58e-06 PS=1.85e-06 $X=3235 $Y=660 $dt=83
M3 5 7 2 2 ne3 L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=1.1368e-12 PD=1.43e-06 PS=4.37e-06 $X=5290 $Y=660 $dt=83
M4 2 7 5 2 ne3 L=3.5e-07 W=8.9e-07 AD=7.214e-13 AS=2.403e-13 PD=3.7e-06 PS=1.43e-06 $X=6180 $Y=660 $dt=83
M5 8 4 3 1 pe3 L=3.0008e-07 W=1.47627e-06 AD=6.21587e-13 AS=5.264e-13 PD=3.96234e-06 PS=3.68627e-06 $X=620 $Y=2410 $dt=86
M6 10 7 1 1 pe3 L=3e-07 W=4.2e-07 AD=5.25e-14 AS=3.086e-13 PD=6.7e-07 PS=2.7e-06 $X=1990 $Y=3060 $dt=86
M7 6 8 10 1 pe3 L=3e-07 W=4.2e-07 AD=2.71e-13 AS=5.25e-14 PD=2.32071e-06 PS=6.7e-07 $X=2540 $Y=3060 $dt=86
M8 9 4 7 1 pe3 L=3e-07 W=4.2e-07 AD=5.25e-14 AS=2.32287e-13 PD=6.7e-07 PS=1.98778e-06 $X=3965 $Y=3400 $dt=86
M9 1 6 9 1 pe3 L=3e-07 W=4.2e-07 AD=1.52026e-13 AS=5.25e-14 PD=8.95082e-07 PS=6.7e-07 $X=4515 $Y=3400 $dt=86
M10 5 7 1 1 pe3 L=3e-07 W=1.41e-06 AD=3.84225e-13 AS=5.10374e-13 PD=1.955e-06 PS=3.00492e-06 $X=5355 $Y=2410 $dt=86
M11 1 7 5 1 pe3 L=3e-07 W=1.41e-06 AD=1.0914e-12 AS=3.84225e-13 PD=4.8e-06 PS=1.955e-06 $X=6200 $Y=2410 $dt=86
D12 2 1 p_dnw3 AREA=2.43707e-11 PJ=2.30544e-05 perimeter=2.30544e-05 $X=-430 $Y=1980 $dt=243
.ends LSHVT18U3VX2

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: nedia_bjt_CDNS_128                              *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt nedia_bjt_CDNS_128 1 2 3
** N=3 EP=3 FDC=1
X0 2 2 3 1 LDDN w=4e-05 l=1.25e-06 adio=9.76316e-10 pdio=0.00012535 extlay=1 $[nedia_bjt] $X=-680 $Y=-4850 $dt=67
.ends nedia_bjt_CDNS_128

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ped_bjt_CDNS_129                                *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ped_bjt_CDNS_129 1 2 3 4
** N=4 EP=4 FDC=1
X0 2 3 4 1 LDDP w=3e-05 l=9.4e-07 ad=2.16315e-10 pd=0.00011484 adio=6.07846e-10 pdio=9.48181e-05 extlay=1 $[ped_bjt] $X=-2270 $Y=0 $dt=68
.ends ped_bjt_CDNS_129

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: nedia_bjt_CDNS_130                              *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt nedia_bjt_CDNS_130 1 2 3
** N=3 EP=3 FDC=1
X0 2 3 1 1 LDDN w=1e-05 l=1.25e-06 adio=6.47216e-10 pdio=9.53501e-05 extlay=1 $[nedia_bjt] $X=-680 $Y=-4850 $dt=67
.ends nedia_bjt_CDNS_130

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_131                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_131 1 2
** N=2 EP=2 FDC=0
.ends VIA3_C_CDNS_131

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_132                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_132 1 2
** N=2 EP=2 FDC=0
.ends VIA3_C_CDNS_132

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_133                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_133 1
** N=1 EP=1 FDC=0
.ends VIA3_C_CDNS_133

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_134                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_134 1 2
** N=2 EP=2 FDC=0
.ends VIA2_C_CDNS_134

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_135                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_135 1 2
** N=2 EP=2 FDC=0
.ends VIA1_C_CDNS_135

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_136                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_136 1
** N=1 EP=1 FDC=0
.ends VIA3_C_CDNS_136

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_137                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_137 1
** N=1 EP=1 FDC=0
.ends VIA3_C_CDNS_137

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_138                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_138 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_138

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_139                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_139 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_139

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_140                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_140 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_140

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_141                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_141 1
** N=1 EP=1 FDC=0
.ends VIA3_C_CDNS_141

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_142                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_142 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_142

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_143                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_143 1
** N=1 EP=1 FDC=0
.ends VIA3_C_CDNS_143

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_144                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_144 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_144

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_145                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_145 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_145

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_146                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_146 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_146

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_147                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_147 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_147

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ne3_CDNS_148                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ne3_CDNS_148 1 2 3
** N=3 EP=3 FDC=1
M0 3 2 1 1 ne3 L=3e-06 W=1.2e-05 AD=5.76e-12 AS=5.76e-12 PD=2.496e-05 PS=2.496e-05 $X=0 $Y=0 $dt=83
.ends ne3_CDNS_148

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: CurrentMirror_x10_LV                            *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt CurrentMirror_x10_LV 1 2 3
** N=3 EP=3 FDC=66
X0 1 VIA2_C_CDNS_49 $T=16730 30475 0 0 $X=16240 $Y=29205
X1 1 VIA2_C_CDNS_49 $T=16730 51065 0 0 $X=16240 $Y=49795
X2 3 VIA2_C_CDNS_49 $T=20930 33755 0 0 $X=20440 $Y=32485
X3 3 VIA2_C_CDNS_49 $T=20930 54345 0 0 $X=20440 $Y=53075
X4 1 VIA2_C_CDNS_49 $T=22530 30475 0 0 $X=22040 $Y=29205
X5 1 VIA2_C_CDNS_49 $T=22530 51065 0 0 $X=22040 $Y=49795
X6 3 VIA2_C_CDNS_49 $T=26730 33755 0 0 $X=26240 $Y=32485
X7 3 VIA2_C_CDNS_49 $T=26730 54345 0 0 $X=26240 $Y=53075
X8 1 VIA2_C_CDNS_49 $T=28330 30475 0 0 $X=27840 $Y=29205
X9 1 VIA2_C_CDNS_49 $T=28330 51065 0 0 $X=27840 $Y=49795
X10 3 VIA2_C_CDNS_49 $T=32530 33755 0 0 $X=32040 $Y=32485
X11 3 VIA2_C_CDNS_49 $T=32530 54345 0 0 $X=32040 $Y=53075
X12 1 VIA2_C_CDNS_49 $T=34130 30475 0 0 $X=33640 $Y=29205
X13 1 VIA2_C_CDNS_49 $T=34130 51065 0 0 $X=33640 $Y=49795
X14 3 VIA2_C_CDNS_49 $T=38330 33755 0 0 $X=37840 $Y=32485
X15 3 VIA2_C_CDNS_49 $T=38330 54345 0 0 $X=37840 $Y=53075
X16 1 VIA2_C_CDNS_49 $T=39930 30475 0 0 $X=39440 $Y=29205
X17 1 VIA2_C_CDNS_49 $T=39930 51065 0 0 $X=39440 $Y=49795
X18 3 VIA2_C_CDNS_49 $T=44130 33755 0 0 $X=43640 $Y=32485
X19 3 VIA2_C_CDNS_49 $T=44130 54345 0 0 $X=43640 $Y=53075
X20 1 VIA2_C_CDNS_49 $T=45730 30475 0 0 $X=45240 $Y=29205
X21 1 VIA2_C_CDNS_49 $T=45730 51065 0 0 $X=45240 $Y=49795
X22 3 VIA2_C_CDNS_49 $T=49930 33755 0 0 $X=49440 $Y=32485
X23 3 VIA2_C_CDNS_49 $T=49930 54345 0 0 $X=49440 $Y=53075
X24 1 VIA2_C_CDNS_49 $T=51530 30475 0 0 $X=51040 $Y=29205
X25 1 VIA2_C_CDNS_49 $T=51530 51065 0 0 $X=51040 $Y=49795
X26 3 VIA2_C_CDNS_49 $T=55730 33755 0 0 $X=55240 $Y=32485
X27 3 VIA2_C_CDNS_49 $T=55730 54345 0 0 $X=55240 $Y=53075
X28 1 VIA2_C_CDNS_49 $T=57330 30475 0 0 $X=56840 $Y=29205
X29 1 VIA2_C_CDNS_49 $T=57330 51065 0 0 $X=56840 $Y=49795
X30 3 VIA2_C_CDNS_49 $T=61530 33755 0 0 $X=61040 $Y=32485
X31 3 VIA2_C_CDNS_49 $T=61530 54345 0 0 $X=61040 $Y=53075
X32 1 VIA2_C_CDNS_49 $T=63130 30475 0 0 $X=62640 $Y=29205
X33 1 VIA2_C_CDNS_49 $T=63130 51065 0 0 $X=62640 $Y=49795
X34 3 VIA2_C_CDNS_49 $T=67330 33755 0 0 $X=66840 $Y=32485
X35 3 VIA2_C_CDNS_49 $T=67330 54345 0 0 $X=66840 $Y=53075
X36 1 VIA2_C_CDNS_49 $T=68930 30475 0 0 $X=68440 $Y=29205
X37 1 VIA2_C_CDNS_49 $T=68930 51065 0 0 $X=68440 $Y=49795
X38 3 VIA2_C_CDNS_49 $T=73130 33755 0 0 $X=72640 $Y=32485
X39 1 VIA2_C_CDNS_49 $T=74730 30475 0 0 $X=74240 $Y=29205
X40 1 VIA2_C_CDNS_49 $T=74730 51065 0 0 $X=74240 $Y=49795
X41 3 VIA2_C_CDNS_49 $T=78930 54345 0 0 $X=78440 $Y=53075
X42 1 VIA2_C_CDNS_49 $T=80530 30475 0 0 $X=80040 $Y=29205
X43 1 VIA2_C_CDNS_49 $T=80530 51065 0 0 $X=80040 $Y=49795
X44 3 VIA2_C_CDNS_49 $T=84730 54345 0 0 $X=84240 $Y=53075
X45 3 VIA2_C_CDNS_49 $T=86330 33755 1 180 $X=85840 $Y=32485
X46 1 VIA2_C_CDNS_49 $T=90530 30475 1 180 $X=90040 $Y=29205
X47 1 VIA2_C_CDNS_49 $T=90530 51065 1 180 $X=90040 $Y=49795
X48 3 VIA2_C_CDNS_49 $T=92130 33755 1 180 $X=91640 $Y=32485
X49 3 VIA2_C_CDNS_49 $T=92130 54345 1 180 $X=91640 $Y=53075
X50 1 VIA2_C_CDNS_49 $T=96330 30475 1 180 $X=95840 $Y=29205
X51 1 VIA2_C_CDNS_49 $T=96330 51065 1 180 $X=95840 $Y=49795
X52 3 VIA2_C_CDNS_49 $T=97930 33755 1 180 $X=97440 $Y=32485
X53 3 VIA2_C_CDNS_49 $T=97930 54345 1 180 $X=97440 $Y=53075
X54 1 VIA2_C_CDNS_49 $T=102130 30475 1 180 $X=101640 $Y=29205
X55 1 VIA2_C_CDNS_49 $T=102130 51065 1 180 $X=101640 $Y=49795
X56 3 VIA2_C_CDNS_49 $T=103730 33755 1 180 $X=103240 $Y=32485
X57 3 VIA2_C_CDNS_49 $T=103730 54345 1 180 $X=103240 $Y=53075
X58 1 VIA2_C_CDNS_49 $T=107930 30475 1 180 $X=107440 $Y=29205
X59 1 VIA2_C_CDNS_49 $T=107930 51065 1 180 $X=107440 $Y=49795
X60 3 VIA2_C_CDNS_49 $T=109530 33755 1 180 $X=109040 $Y=32485
X61 3 VIA2_C_CDNS_49 $T=109530 54345 1 180 $X=109040 $Y=53075
X62 1 VIA2_C_CDNS_49 $T=113730 30475 1 180 $X=113240 $Y=29205
X63 1 VIA2_C_CDNS_49 $T=113730 51065 1 180 $X=113240 $Y=49795
X64 3 VIA2_C_CDNS_49 $T=115330 33755 1 180 $X=114840 $Y=32485
X65 3 VIA2_C_CDNS_49 $T=115330 54345 1 180 $X=114840 $Y=53075
X66 1 VIA2_C_CDNS_49 $T=119530 30475 1 180 $X=119040 $Y=29205
X67 1 VIA2_C_CDNS_49 $T=119530 51065 1 180 $X=119040 $Y=49795
X68 3 VIA2_C_CDNS_49 $T=121130 33755 1 180 $X=120640 $Y=32485
X69 3 VIA2_C_CDNS_49 $T=121130 54345 1 180 $X=120640 $Y=53075
X70 1 VIA2_C_CDNS_49 $T=125330 30475 1 180 $X=124840 $Y=29205
X71 1 VIA2_C_CDNS_49 $T=125330 51065 1 180 $X=124840 $Y=49795
X72 3 VIA2_C_CDNS_49 $T=126930 33755 1 180 $X=126440 $Y=32485
X73 3 VIA2_C_CDNS_49 $T=126930 54345 1 180 $X=126440 $Y=53075
X74 1 VIA2_C_CDNS_49 $T=131130 30475 1 180 $X=130640 $Y=29205
X75 1 VIA2_C_CDNS_49 $T=131130 51065 1 180 $X=130640 $Y=49795
X76 3 VIA2_C_CDNS_49 $T=132730 33755 1 180 $X=132240 $Y=32485
X77 3 VIA2_C_CDNS_49 $T=132730 54345 1 180 $X=132240 $Y=53075
X78 1 VIA2_C_CDNS_49 $T=136930 30475 1 180 $X=136440 $Y=29205
X79 1 VIA2_C_CDNS_49 $T=136930 51065 1 180 $X=136440 $Y=49795
X80 3 VIA2_C_CDNS_49 $T=138530 33755 1 180 $X=138040 $Y=32485
X81 3 VIA2_C_CDNS_49 $T=138530 54345 1 180 $X=138040 $Y=53075
X82 1 VIA2_C_CDNS_49 $T=142730 30475 1 180 $X=142240 $Y=29205
X83 1 VIA2_C_CDNS_49 $T=142730 51065 1 180 $X=142240 $Y=49795
X84 2 VIA2_C_CDNS_62 $T=15230 14470 0 0 $X=14780 $Y=14330
X85 2 VIA2_C_CDNS_62 $T=15230 28500 0 0 $X=14780 $Y=28360
X86 2 VIA2_C_CDNS_62 $T=15230 49090 0 0 $X=14780 $Y=48950
X87 2 VIA2_C_CDNS_62 $T=15230 69680 0 0 $X=14780 $Y=69540
X88 2 VIA2_C_CDNS_62 $T=144230 14470 0 0 $X=143780 $Y=14330
X89 2 VIA2_C_CDNS_62 $T=144230 28500 0 0 $X=143780 $Y=28360
X90 2 VIA2_C_CDNS_62 $T=144230 49090 0 0 $X=143780 $Y=48950
X91 2 VIA2_C_CDNS_62 $T=144230 69680 0 0 $X=143780 $Y=69540
X92 2 VIA1_C_CDNS_77 $T=18830 28500 0 0 $X=18080 $Y=28270
X93 2 VIA1_C_CDNS_77 $T=18830 49090 0 0 $X=18080 $Y=48860
X94 2 VIA1_C_CDNS_77 $T=18830 69680 0 0 $X=18080 $Y=69450
X95 2 VIA1_C_CDNS_77 $T=24630 28500 0 0 $X=23880 $Y=28270
X96 2 VIA1_C_CDNS_77 $T=24630 49090 0 0 $X=23880 $Y=48860
X97 2 VIA1_C_CDNS_77 $T=24630 69680 0 0 $X=23880 $Y=69450
X98 2 VIA1_C_CDNS_77 $T=30430 28500 0 0 $X=29680 $Y=28270
X99 2 VIA1_C_CDNS_77 $T=30430 49090 0 0 $X=29680 $Y=48860
X100 2 VIA1_C_CDNS_77 $T=30430 69680 0 0 $X=29680 $Y=69450
X101 2 VIA1_C_CDNS_77 $T=36230 28500 0 0 $X=35480 $Y=28270
X102 2 VIA1_C_CDNS_77 $T=36230 49090 0 0 $X=35480 $Y=48860
X103 2 VIA1_C_CDNS_77 $T=36230 69680 0 0 $X=35480 $Y=69450
X104 2 VIA1_C_CDNS_77 $T=42030 28500 0 0 $X=41280 $Y=28270
X105 2 VIA1_C_CDNS_77 $T=42030 49090 0 0 $X=41280 $Y=48860
X106 2 VIA1_C_CDNS_77 $T=42030 69680 0 0 $X=41280 $Y=69450
X107 2 VIA1_C_CDNS_77 $T=47830 28500 0 0 $X=47080 $Y=28270
X108 2 VIA1_C_CDNS_77 $T=47830 49090 0 0 $X=47080 $Y=48860
X109 2 VIA1_C_CDNS_77 $T=47830 69680 0 0 $X=47080 $Y=69450
X110 2 VIA1_C_CDNS_77 $T=53630 28500 0 0 $X=52880 $Y=28270
X111 2 VIA1_C_CDNS_77 $T=53630 49090 0 0 $X=52880 $Y=48860
X112 2 VIA1_C_CDNS_77 $T=53630 69680 0 0 $X=52880 $Y=69450
X113 2 VIA1_C_CDNS_77 $T=59430 28500 0 0 $X=58680 $Y=28270
X114 2 VIA1_C_CDNS_77 $T=59430 49090 0 0 $X=58680 $Y=48860
X115 2 VIA1_C_CDNS_77 $T=59430 69680 0 0 $X=58680 $Y=69450
X116 2 VIA1_C_CDNS_77 $T=65230 28500 0 0 $X=64480 $Y=28270
X117 2 VIA1_C_CDNS_77 $T=65230 49090 0 0 $X=64480 $Y=48860
X118 2 VIA1_C_CDNS_77 $T=65230 69680 0 0 $X=64480 $Y=69450
X119 2 VIA1_C_CDNS_77 $T=71030 28500 0 0 $X=70280 $Y=28270
X120 2 VIA1_C_CDNS_77 $T=71030 49090 0 0 $X=70280 $Y=48860
X121 2 VIA1_C_CDNS_77 $T=71030 69680 0 0 $X=70280 $Y=69450
X122 2 VIA1_C_CDNS_77 $T=76830 28500 0 0 $X=76080 $Y=28270
X123 2 VIA1_C_CDNS_77 $T=76830 49090 0 0 $X=76080 $Y=48860
X124 2 VIA1_C_CDNS_77 $T=76830 69680 0 0 $X=76080 $Y=69450
X125 2 VIA1_C_CDNS_77 $T=82630 28500 0 0 $X=81880 $Y=28270
X126 2 VIA1_C_CDNS_77 $T=82630 49090 0 0 $X=81880 $Y=48860
X127 2 VIA1_C_CDNS_77 $T=82630 69680 0 0 $X=81880 $Y=69450
X128 2 VIA1_C_CDNS_77 $T=88430 28500 0 0 $X=87680 $Y=28270
X129 2 VIA1_C_CDNS_77 $T=88430 49090 0 0 $X=87680 $Y=48860
X130 2 VIA1_C_CDNS_77 $T=88430 69680 0 0 $X=87680 $Y=69450
X131 2 VIA1_C_CDNS_77 $T=94230 28500 0 0 $X=93480 $Y=28270
X132 2 VIA1_C_CDNS_77 $T=94230 49090 0 0 $X=93480 $Y=48860
X133 2 VIA1_C_CDNS_77 $T=94230 69680 0 0 $X=93480 $Y=69450
X134 2 VIA1_C_CDNS_77 $T=100030 28500 0 0 $X=99280 $Y=28270
X135 2 VIA1_C_CDNS_77 $T=100030 49090 0 0 $X=99280 $Y=48860
X136 2 VIA1_C_CDNS_77 $T=100030 69680 0 0 $X=99280 $Y=69450
X137 2 VIA1_C_CDNS_77 $T=105830 28500 0 0 $X=105080 $Y=28270
X138 2 VIA1_C_CDNS_77 $T=105830 49090 0 0 $X=105080 $Y=48860
X139 2 VIA1_C_CDNS_77 $T=105830 69680 0 0 $X=105080 $Y=69450
X140 2 VIA1_C_CDNS_77 $T=111630 28500 0 0 $X=110880 $Y=28270
X141 2 VIA1_C_CDNS_77 $T=111630 49090 0 0 $X=110880 $Y=48860
X142 2 VIA1_C_CDNS_77 $T=111630 69680 0 0 $X=110880 $Y=69450
X143 2 VIA1_C_CDNS_77 $T=117430 28500 0 0 $X=116680 $Y=28270
X144 2 VIA1_C_CDNS_77 $T=117430 49090 0 0 $X=116680 $Y=48860
X145 2 VIA1_C_CDNS_77 $T=117430 69680 0 0 $X=116680 $Y=69450
X146 2 VIA1_C_CDNS_77 $T=123230 28500 0 0 $X=122480 $Y=28270
X147 2 VIA1_C_CDNS_77 $T=123230 49090 0 0 $X=122480 $Y=48860
X148 2 VIA1_C_CDNS_77 $T=123230 69680 0 0 $X=122480 $Y=69450
X149 2 VIA1_C_CDNS_77 $T=129030 28500 0 0 $X=128280 $Y=28270
X150 2 VIA1_C_CDNS_77 $T=129030 49090 0 0 $X=128280 $Y=48860
X151 2 VIA1_C_CDNS_77 $T=129030 69680 0 0 $X=128280 $Y=69450
X152 2 VIA1_C_CDNS_77 $T=134830 28500 0 0 $X=134080 $Y=28270
X153 2 VIA1_C_CDNS_77 $T=134830 49090 0 0 $X=134080 $Y=48860
X154 2 VIA1_C_CDNS_77 $T=134830 69680 0 0 $X=134080 $Y=69450
X155 2 VIA1_C_CDNS_77 $T=140630 28500 0 0 $X=139880 $Y=28270
X156 2 VIA1_C_CDNS_77 $T=140630 49090 0 0 $X=139880 $Y=48860
X157 2 VIA1_C_CDNS_77 $T=140630 69680 0 0 $X=139880 $Y=69450
X158 1 VIA2_C_CDNS_115 $T=3310 6160 0 0 $X=3080 $Y=3850
X159 1 VIA2_C_CDNS_115 $T=3310 77990 0 0 $X=3080 $Y=75680
X160 1 VIA2_C_CDNS_115 $T=156150 6160 0 0 $X=155920 $Y=3850
X161 1 VIA2_C_CDNS_115 $T=156150 77990 0 0 $X=155920 $Y=75680
X162 2 VIA1_C_CDNS_124 $T=73130 14470 0 0 $X=72640 $Y=14240
X163 2 VIA1_C_CDNS_124 $T=73130 49090 0 0 $X=72640 $Y=48860
X164 2 VIA1_C_CDNS_124 $T=78930 28500 0 0 $X=78440 $Y=28270
X165 2 VIA1_C_CDNS_124 $T=84730 28500 0 0 $X=84240 $Y=28270
X166 2 VIA1_C_CDNS_124 $T=86330 14470 0 0 $X=85840 $Y=14240
X167 2 VIA1_C_CDNS_124 $T=86330 49090 0 0 $X=85840 $Y=48860
X168 1 1 VIA3_C_CDNS_131 $T=6670 30530 0 0 $X=4450 $Y=29300
X169 1 1 VIA3_C_CDNS_131 $T=6670 51120 0 0 $X=4450 $Y=49890
X170 3 1 VIA3_C_CDNS_131 $T=11950 33810 0 0 $X=9730 $Y=32580
X171 3 1 VIA3_C_CDNS_131 $T=11950 54400 0 0 $X=9730 $Y=53170
X172 3 1 VIA3_C_CDNS_131 $T=147510 33810 0 0 $X=145290 $Y=32580
X173 3 1 VIA3_C_CDNS_131 $T=147510 54400 0 0 $X=145290 $Y=53170
X174 1 1 VIA3_C_CDNS_131 $T=152790 30530 0 0 $X=150570 $Y=29300
X175 1 1 VIA3_C_CDNS_131 $T=152790 51120 0 0 $X=150570 $Y=49890
X176 3 1 VIA3_C_CDNS_132 $T=11950 11440 0 0 $X=9680 $Y=9170
X177 3 1 VIA3_C_CDNS_132 $T=11950 72710 0 0 $X=9680 $Y=70440
X178 3 1 VIA3_C_CDNS_132 $T=147510 11440 0 0 $X=145240 $Y=9170
X179 3 1 VIA3_C_CDNS_132 $T=147510 72710 0 0 $X=145240 $Y=70440
X180 1 VIA3_C_CDNS_133 $T=6670 6160 0 0 $X=4400 $Y=3890
X181 1 VIA3_C_CDNS_133 $T=6670 77990 0 0 $X=4400 $Y=75720
X182 1 VIA3_C_CDNS_133 $T=152790 6160 0 0 $X=150520 $Y=3890
X183 1 VIA3_C_CDNS_133 $T=152790 77990 0 0 $X=150520 $Y=75720
X184 1 1 VIA2_C_CDNS_134 $T=16730 21400 0 0 $X=16230 $Y=15440
X185 1 1 VIA2_C_CDNS_134 $T=16730 41990 0 0 $X=16230 $Y=36030
X186 1 1 VIA2_C_CDNS_134 $T=16730 62580 0 0 $X=16230 $Y=56620
X187 3 1 VIA2_C_CDNS_134 $T=20930 21400 0 0 $X=20430 $Y=15440
X188 3 1 VIA2_C_CDNS_134 $T=20930 41990 0 0 $X=20430 $Y=36030
X189 3 1 VIA2_C_CDNS_134 $T=20930 62580 0 0 $X=20430 $Y=56620
X190 1 1 VIA2_C_CDNS_134 $T=22530 21400 0 0 $X=22030 $Y=15440
X191 1 1 VIA2_C_CDNS_134 $T=22530 41990 0 0 $X=22030 $Y=36030
X192 1 1 VIA2_C_CDNS_134 $T=22530 62580 0 0 $X=22030 $Y=56620
X193 3 1 VIA2_C_CDNS_134 $T=26730 21400 0 0 $X=26230 $Y=15440
X194 3 1 VIA2_C_CDNS_134 $T=26730 41990 0 0 $X=26230 $Y=36030
X195 3 1 VIA2_C_CDNS_134 $T=26730 62580 0 0 $X=26230 $Y=56620
X196 1 1 VIA2_C_CDNS_134 $T=28330 21400 0 0 $X=27830 $Y=15440
X197 1 1 VIA2_C_CDNS_134 $T=28330 41990 0 0 $X=27830 $Y=36030
X198 1 1 VIA2_C_CDNS_134 $T=28330 62580 0 0 $X=27830 $Y=56620
X199 3 1 VIA2_C_CDNS_134 $T=32530 21400 0 0 $X=32030 $Y=15440
X200 3 1 VIA2_C_CDNS_134 $T=32530 41990 0 0 $X=32030 $Y=36030
X201 3 1 VIA2_C_CDNS_134 $T=32530 62580 0 0 $X=32030 $Y=56620
X202 1 1 VIA2_C_CDNS_134 $T=34130 21400 0 0 $X=33630 $Y=15440
X203 1 1 VIA2_C_CDNS_134 $T=34130 41990 0 0 $X=33630 $Y=36030
X204 1 1 VIA2_C_CDNS_134 $T=34130 62580 0 0 $X=33630 $Y=56620
X205 3 1 VIA2_C_CDNS_134 $T=38330 21400 0 0 $X=37830 $Y=15440
X206 3 1 VIA2_C_CDNS_134 $T=38330 41990 0 0 $X=37830 $Y=36030
X207 3 1 VIA2_C_CDNS_134 $T=38330 62580 0 0 $X=37830 $Y=56620
X208 1 1 VIA2_C_CDNS_134 $T=39930 21400 0 0 $X=39430 $Y=15440
X209 1 1 VIA2_C_CDNS_134 $T=39930 41990 0 0 $X=39430 $Y=36030
X210 1 1 VIA2_C_CDNS_134 $T=39930 62580 0 0 $X=39430 $Y=56620
X211 3 1 VIA2_C_CDNS_134 $T=44130 21400 0 0 $X=43630 $Y=15440
X212 3 1 VIA2_C_CDNS_134 $T=44130 41990 0 0 $X=43630 $Y=36030
X213 3 1 VIA2_C_CDNS_134 $T=44130 62580 0 0 $X=43630 $Y=56620
X214 1 1 VIA2_C_CDNS_134 $T=45730 21400 0 0 $X=45230 $Y=15440
X215 1 1 VIA2_C_CDNS_134 $T=45730 41990 0 0 $X=45230 $Y=36030
X216 1 1 VIA2_C_CDNS_134 $T=45730 62580 0 0 $X=45230 $Y=56620
X217 3 1 VIA2_C_CDNS_134 $T=49930 21400 0 0 $X=49430 $Y=15440
X218 3 1 VIA2_C_CDNS_134 $T=49930 41990 0 0 $X=49430 $Y=36030
X219 3 1 VIA2_C_CDNS_134 $T=49930 62580 0 0 $X=49430 $Y=56620
X220 1 1 VIA2_C_CDNS_134 $T=51530 21400 0 0 $X=51030 $Y=15440
X221 1 1 VIA2_C_CDNS_134 $T=51530 41990 0 0 $X=51030 $Y=36030
X222 1 1 VIA2_C_CDNS_134 $T=51530 62580 0 0 $X=51030 $Y=56620
X223 3 1 VIA2_C_CDNS_134 $T=55730 21400 0 0 $X=55230 $Y=15440
X224 3 1 VIA2_C_CDNS_134 $T=55730 41990 0 0 $X=55230 $Y=36030
X225 3 1 VIA2_C_CDNS_134 $T=55730 62580 0 0 $X=55230 $Y=56620
X226 1 1 VIA2_C_CDNS_134 $T=57330 21400 0 0 $X=56830 $Y=15440
X227 1 1 VIA2_C_CDNS_134 $T=57330 41990 0 0 $X=56830 $Y=36030
X228 1 1 VIA2_C_CDNS_134 $T=57330 62580 0 0 $X=56830 $Y=56620
X229 3 1 VIA2_C_CDNS_134 $T=61530 21400 0 0 $X=61030 $Y=15440
X230 3 1 VIA2_C_CDNS_134 $T=61530 41990 0 0 $X=61030 $Y=36030
X231 3 1 VIA2_C_CDNS_134 $T=61530 62580 0 0 $X=61030 $Y=56620
X232 1 1 VIA2_C_CDNS_134 $T=63130 21400 0 0 $X=62630 $Y=15440
X233 1 1 VIA2_C_CDNS_134 $T=63130 41990 0 0 $X=62630 $Y=36030
X234 1 1 VIA2_C_CDNS_134 $T=63130 62580 0 0 $X=62630 $Y=56620
X235 3 1 VIA2_C_CDNS_134 $T=67330 21400 0 0 $X=66830 $Y=15440
X236 3 1 VIA2_C_CDNS_134 $T=67330 41990 0 0 $X=66830 $Y=36030
X237 3 1 VIA2_C_CDNS_134 $T=67330 62580 0 0 $X=66830 $Y=56620
X238 1 1 VIA2_C_CDNS_134 $T=68930 21400 0 0 $X=68430 $Y=15440
X239 1 1 VIA2_C_CDNS_134 $T=68930 41990 0 0 $X=68430 $Y=36030
X240 1 1 VIA2_C_CDNS_134 $T=68930 62580 0 0 $X=68430 $Y=56620
X241 3 1 VIA2_C_CDNS_134 $T=73130 41990 0 0 $X=72630 $Y=36030
X242 1 1 VIA2_C_CDNS_134 $T=74730 21400 0 0 $X=74230 $Y=15440
X243 1 1 VIA2_C_CDNS_134 $T=74730 41990 0 0 $X=74230 $Y=36030
X244 1 1 VIA2_C_CDNS_134 $T=74730 62580 0 0 $X=74230 $Y=56620
X245 3 1 VIA2_C_CDNS_134 $T=78930 21400 0 0 $X=78430 $Y=15440
X246 3 1 VIA2_C_CDNS_134 $T=78930 62580 0 0 $X=78430 $Y=56620
X247 1 1 VIA2_C_CDNS_134 $T=80530 21400 0 0 $X=80030 $Y=15440
X248 1 1 VIA2_C_CDNS_134 $T=80530 41990 0 0 $X=80030 $Y=36030
X249 1 1 VIA2_C_CDNS_134 $T=80530 62580 0 0 $X=80030 $Y=56620
X250 3 1 VIA2_C_CDNS_134 $T=84730 21400 0 0 $X=84230 $Y=15440
X251 3 1 VIA2_C_CDNS_134 $T=84730 62580 0 0 $X=84230 $Y=56620
X252 3 1 VIA2_C_CDNS_134 $T=86330 41990 1 180 $X=85830 $Y=36030
X253 1 1 VIA2_C_CDNS_134 $T=90530 21400 1 180 $X=90030 $Y=15440
X254 1 1 VIA2_C_CDNS_134 $T=90530 41990 1 180 $X=90030 $Y=36030
X255 1 1 VIA2_C_CDNS_134 $T=90530 62580 1 180 $X=90030 $Y=56620
X256 3 1 VIA2_C_CDNS_134 $T=92130 21400 1 180 $X=91630 $Y=15440
X257 3 1 VIA2_C_CDNS_134 $T=92130 41990 1 180 $X=91630 $Y=36030
X258 3 1 VIA2_C_CDNS_134 $T=92130 62580 1 180 $X=91630 $Y=56620
X259 1 1 VIA2_C_CDNS_134 $T=96330 21400 1 180 $X=95830 $Y=15440
X260 1 1 VIA2_C_CDNS_134 $T=96330 41990 1 180 $X=95830 $Y=36030
X261 1 1 VIA2_C_CDNS_134 $T=96330 62580 1 180 $X=95830 $Y=56620
X262 3 1 VIA2_C_CDNS_134 $T=97930 21400 1 180 $X=97430 $Y=15440
X263 3 1 VIA2_C_CDNS_134 $T=97930 41990 1 180 $X=97430 $Y=36030
X264 3 1 VIA2_C_CDNS_134 $T=97930 62580 1 180 $X=97430 $Y=56620
X265 1 1 VIA2_C_CDNS_134 $T=102130 21400 1 180 $X=101630 $Y=15440
X266 1 1 VIA2_C_CDNS_134 $T=102130 41990 1 180 $X=101630 $Y=36030
X267 1 1 VIA2_C_CDNS_134 $T=102130 62580 1 180 $X=101630 $Y=56620
X268 3 1 VIA2_C_CDNS_134 $T=103730 21400 1 180 $X=103230 $Y=15440
X269 3 1 VIA2_C_CDNS_134 $T=103730 41990 1 180 $X=103230 $Y=36030
X270 3 1 VIA2_C_CDNS_134 $T=103730 62580 1 180 $X=103230 $Y=56620
X271 1 1 VIA2_C_CDNS_134 $T=107930 21400 1 180 $X=107430 $Y=15440
X272 1 1 VIA2_C_CDNS_134 $T=107930 41990 1 180 $X=107430 $Y=36030
X273 1 1 VIA2_C_CDNS_134 $T=107930 62580 1 180 $X=107430 $Y=56620
X274 3 1 VIA2_C_CDNS_134 $T=109530 21400 1 180 $X=109030 $Y=15440
X275 3 1 VIA2_C_CDNS_134 $T=109530 41990 1 180 $X=109030 $Y=36030
X276 3 1 VIA2_C_CDNS_134 $T=109530 62580 1 180 $X=109030 $Y=56620
X277 1 1 VIA2_C_CDNS_134 $T=113730 21400 1 180 $X=113230 $Y=15440
X278 1 1 VIA2_C_CDNS_134 $T=113730 41990 1 180 $X=113230 $Y=36030
X279 1 1 VIA2_C_CDNS_134 $T=113730 62580 1 180 $X=113230 $Y=56620
X280 3 1 VIA2_C_CDNS_134 $T=115330 21400 1 180 $X=114830 $Y=15440
X281 3 1 VIA2_C_CDNS_134 $T=115330 41990 1 180 $X=114830 $Y=36030
X282 3 1 VIA2_C_CDNS_134 $T=115330 62580 1 180 $X=114830 $Y=56620
X283 1 1 VIA2_C_CDNS_134 $T=119530 21400 1 180 $X=119030 $Y=15440
X284 1 1 VIA2_C_CDNS_134 $T=119530 41990 1 180 $X=119030 $Y=36030
X285 1 1 VIA2_C_CDNS_134 $T=119530 62580 1 180 $X=119030 $Y=56620
X286 3 1 VIA2_C_CDNS_134 $T=121130 21400 1 180 $X=120630 $Y=15440
X287 3 1 VIA2_C_CDNS_134 $T=121130 41990 1 180 $X=120630 $Y=36030
X288 3 1 VIA2_C_CDNS_134 $T=121130 62580 1 180 $X=120630 $Y=56620
X289 1 1 VIA2_C_CDNS_134 $T=125330 21400 1 180 $X=124830 $Y=15440
X290 1 1 VIA2_C_CDNS_134 $T=125330 41990 1 180 $X=124830 $Y=36030
X291 1 1 VIA2_C_CDNS_134 $T=125330 62580 1 180 $X=124830 $Y=56620
X292 3 1 VIA2_C_CDNS_134 $T=126930 21400 1 180 $X=126430 $Y=15440
X293 3 1 VIA2_C_CDNS_134 $T=126930 41990 1 180 $X=126430 $Y=36030
X294 3 1 VIA2_C_CDNS_134 $T=126930 62580 1 180 $X=126430 $Y=56620
X295 1 1 VIA2_C_CDNS_134 $T=131130 21400 1 180 $X=130630 $Y=15440
X296 1 1 VIA2_C_CDNS_134 $T=131130 41990 1 180 $X=130630 $Y=36030
X297 1 1 VIA2_C_CDNS_134 $T=131130 62580 1 180 $X=130630 $Y=56620
X298 3 1 VIA2_C_CDNS_134 $T=132730 21400 1 180 $X=132230 $Y=15440
X299 3 1 VIA2_C_CDNS_134 $T=132730 41990 1 180 $X=132230 $Y=36030
X300 3 1 VIA2_C_CDNS_134 $T=132730 62580 1 180 $X=132230 $Y=56620
X301 1 1 VIA2_C_CDNS_134 $T=136930 21400 1 180 $X=136430 $Y=15440
X302 1 1 VIA2_C_CDNS_134 $T=136930 41990 1 180 $X=136430 $Y=36030
X303 1 1 VIA2_C_CDNS_134 $T=136930 62580 1 180 $X=136430 $Y=56620
X304 3 1 VIA2_C_CDNS_134 $T=138530 21400 1 180 $X=138030 $Y=15440
X305 3 1 VIA2_C_CDNS_134 $T=138530 41990 1 180 $X=138030 $Y=36030
X306 3 1 VIA2_C_CDNS_134 $T=138530 62580 1 180 $X=138030 $Y=56620
X307 1 1 VIA2_C_CDNS_134 $T=142730 21400 1 180 $X=142230 $Y=15440
X308 1 1 VIA2_C_CDNS_134 $T=142730 41990 1 180 $X=142230 $Y=36030
X309 1 1 VIA2_C_CDNS_134 $T=142730 62580 1 180 $X=142230 $Y=56620
X310 1 1 VIA1_C_CDNS_135 $T=16730 21400 0 0 $X=16230 $Y=15440
X311 1 1 VIA1_C_CDNS_135 $T=16730 41990 0 0 $X=16230 $Y=36030
X312 1 1 VIA1_C_CDNS_135 $T=16730 62580 0 0 $X=16230 $Y=56620
X313 3 1 VIA1_C_CDNS_135 $T=20930 21400 0 0 $X=20430 $Y=15440
X314 3 1 VIA1_C_CDNS_135 $T=20930 41990 0 0 $X=20430 $Y=36030
X315 3 1 VIA1_C_CDNS_135 $T=20930 62580 0 0 $X=20430 $Y=56620
X316 1 1 VIA1_C_CDNS_135 $T=22530 21400 0 0 $X=22030 $Y=15440
X317 1 1 VIA1_C_CDNS_135 $T=22530 41990 0 0 $X=22030 $Y=36030
X318 1 1 VIA1_C_CDNS_135 $T=22530 62580 0 0 $X=22030 $Y=56620
X319 3 1 VIA1_C_CDNS_135 $T=26730 21400 0 0 $X=26230 $Y=15440
X320 3 1 VIA1_C_CDNS_135 $T=26730 41990 0 0 $X=26230 $Y=36030
X321 3 1 VIA1_C_CDNS_135 $T=26730 62580 0 0 $X=26230 $Y=56620
X322 1 1 VIA1_C_CDNS_135 $T=28330 21400 0 0 $X=27830 $Y=15440
X323 1 1 VIA1_C_CDNS_135 $T=28330 41990 0 0 $X=27830 $Y=36030
X324 1 1 VIA1_C_CDNS_135 $T=28330 62580 0 0 $X=27830 $Y=56620
X325 3 1 VIA1_C_CDNS_135 $T=32530 21400 0 0 $X=32030 $Y=15440
X326 3 1 VIA1_C_CDNS_135 $T=32530 41990 0 0 $X=32030 $Y=36030
X327 3 1 VIA1_C_CDNS_135 $T=32530 62580 0 0 $X=32030 $Y=56620
X328 1 1 VIA1_C_CDNS_135 $T=34130 21400 0 0 $X=33630 $Y=15440
X329 1 1 VIA1_C_CDNS_135 $T=34130 41990 0 0 $X=33630 $Y=36030
X330 1 1 VIA1_C_CDNS_135 $T=34130 62580 0 0 $X=33630 $Y=56620
X331 3 1 VIA1_C_CDNS_135 $T=38330 21400 0 0 $X=37830 $Y=15440
X332 3 1 VIA1_C_CDNS_135 $T=38330 41990 0 0 $X=37830 $Y=36030
X333 3 1 VIA1_C_CDNS_135 $T=38330 62580 0 0 $X=37830 $Y=56620
X334 1 1 VIA1_C_CDNS_135 $T=39930 21400 0 0 $X=39430 $Y=15440
X335 1 1 VIA1_C_CDNS_135 $T=39930 41990 0 0 $X=39430 $Y=36030
X336 1 1 VIA1_C_CDNS_135 $T=39930 62580 0 0 $X=39430 $Y=56620
X337 3 1 VIA1_C_CDNS_135 $T=44130 21400 0 0 $X=43630 $Y=15440
X338 3 1 VIA1_C_CDNS_135 $T=44130 41990 0 0 $X=43630 $Y=36030
X339 3 1 VIA1_C_CDNS_135 $T=44130 62580 0 0 $X=43630 $Y=56620
X340 1 1 VIA1_C_CDNS_135 $T=45730 21400 0 0 $X=45230 $Y=15440
X341 1 1 VIA1_C_CDNS_135 $T=45730 41990 0 0 $X=45230 $Y=36030
X342 1 1 VIA1_C_CDNS_135 $T=45730 62580 0 0 $X=45230 $Y=56620
X343 3 1 VIA1_C_CDNS_135 $T=49930 21400 0 0 $X=49430 $Y=15440
X344 3 1 VIA1_C_CDNS_135 $T=49930 41990 0 0 $X=49430 $Y=36030
X345 3 1 VIA1_C_CDNS_135 $T=49930 62580 0 0 $X=49430 $Y=56620
X346 1 1 VIA1_C_CDNS_135 $T=51530 21400 0 0 $X=51030 $Y=15440
X347 1 1 VIA1_C_CDNS_135 $T=51530 41990 0 0 $X=51030 $Y=36030
X348 1 1 VIA1_C_CDNS_135 $T=51530 62580 0 0 $X=51030 $Y=56620
X349 3 1 VIA1_C_CDNS_135 $T=55730 21400 0 0 $X=55230 $Y=15440
X350 3 1 VIA1_C_CDNS_135 $T=55730 41990 0 0 $X=55230 $Y=36030
X351 3 1 VIA1_C_CDNS_135 $T=55730 62580 0 0 $X=55230 $Y=56620
X352 1 1 VIA1_C_CDNS_135 $T=57330 21400 0 0 $X=56830 $Y=15440
X353 1 1 VIA1_C_CDNS_135 $T=57330 41990 0 0 $X=56830 $Y=36030
X354 1 1 VIA1_C_CDNS_135 $T=57330 62580 0 0 $X=56830 $Y=56620
X355 3 1 VIA1_C_CDNS_135 $T=61530 21400 0 0 $X=61030 $Y=15440
X356 3 1 VIA1_C_CDNS_135 $T=61530 41990 0 0 $X=61030 $Y=36030
X357 3 1 VIA1_C_CDNS_135 $T=61530 62580 0 0 $X=61030 $Y=56620
X358 1 1 VIA1_C_CDNS_135 $T=63130 21400 0 0 $X=62630 $Y=15440
X359 1 1 VIA1_C_CDNS_135 $T=63130 41990 0 0 $X=62630 $Y=36030
X360 1 1 VIA1_C_CDNS_135 $T=63130 62580 0 0 $X=62630 $Y=56620
X361 3 1 VIA1_C_CDNS_135 $T=67330 21400 0 0 $X=66830 $Y=15440
X362 3 1 VIA1_C_CDNS_135 $T=67330 41990 0 0 $X=66830 $Y=36030
X363 3 1 VIA1_C_CDNS_135 $T=67330 62580 0 0 $X=66830 $Y=56620
X364 1 1 VIA1_C_CDNS_135 $T=68930 21400 0 0 $X=68430 $Y=15440
X365 1 1 VIA1_C_CDNS_135 $T=68930 41990 0 0 $X=68430 $Y=36030
X366 1 1 VIA1_C_CDNS_135 $T=68930 62580 0 0 $X=68430 $Y=56620
X367 3 1 VIA1_C_CDNS_135 $T=73130 41990 0 0 $X=72630 $Y=36030
X368 1 1 VIA1_C_CDNS_135 $T=74730 21400 0 0 $X=74230 $Y=15440
X369 1 1 VIA1_C_CDNS_135 $T=74730 41990 0 0 $X=74230 $Y=36030
X370 1 1 VIA1_C_CDNS_135 $T=74730 62580 0 0 $X=74230 $Y=56620
X371 3 1 VIA1_C_CDNS_135 $T=78930 21400 0 0 $X=78430 $Y=15440
X372 3 1 VIA1_C_CDNS_135 $T=78930 62580 0 0 $X=78430 $Y=56620
X373 1 1 VIA1_C_CDNS_135 $T=80530 21400 0 0 $X=80030 $Y=15440
X374 1 1 VIA1_C_CDNS_135 $T=80530 41990 0 0 $X=80030 $Y=36030
X375 1 1 VIA1_C_CDNS_135 $T=80530 62580 0 0 $X=80030 $Y=56620
X376 3 1 VIA1_C_CDNS_135 $T=84730 21400 0 0 $X=84230 $Y=15440
X377 3 1 VIA1_C_CDNS_135 $T=84730 62580 0 0 $X=84230 $Y=56620
X378 3 1 VIA1_C_CDNS_135 $T=86330 41990 1 180 $X=85830 $Y=36030
X379 1 1 VIA1_C_CDNS_135 $T=90530 21400 1 180 $X=90030 $Y=15440
X380 1 1 VIA1_C_CDNS_135 $T=90530 41990 1 180 $X=90030 $Y=36030
X381 1 1 VIA1_C_CDNS_135 $T=90530 62580 1 180 $X=90030 $Y=56620
X382 3 1 VIA1_C_CDNS_135 $T=92130 21400 1 180 $X=91630 $Y=15440
X383 3 1 VIA1_C_CDNS_135 $T=92130 41990 1 180 $X=91630 $Y=36030
X384 3 1 VIA1_C_CDNS_135 $T=92130 62580 1 180 $X=91630 $Y=56620
X385 1 1 VIA1_C_CDNS_135 $T=96330 21400 1 180 $X=95830 $Y=15440
X386 1 1 VIA1_C_CDNS_135 $T=96330 41990 1 180 $X=95830 $Y=36030
X387 1 1 VIA1_C_CDNS_135 $T=96330 62580 1 180 $X=95830 $Y=56620
X388 3 1 VIA1_C_CDNS_135 $T=97930 21400 1 180 $X=97430 $Y=15440
X389 3 1 VIA1_C_CDNS_135 $T=97930 41990 1 180 $X=97430 $Y=36030
X390 3 1 VIA1_C_CDNS_135 $T=97930 62580 1 180 $X=97430 $Y=56620
X391 1 1 VIA1_C_CDNS_135 $T=102130 21400 1 180 $X=101630 $Y=15440
X392 1 1 VIA1_C_CDNS_135 $T=102130 41990 1 180 $X=101630 $Y=36030
X393 1 1 VIA1_C_CDNS_135 $T=102130 62580 1 180 $X=101630 $Y=56620
X394 3 1 VIA1_C_CDNS_135 $T=103730 21400 1 180 $X=103230 $Y=15440
X395 3 1 VIA1_C_CDNS_135 $T=103730 41990 1 180 $X=103230 $Y=36030
X396 3 1 VIA1_C_CDNS_135 $T=103730 62580 1 180 $X=103230 $Y=56620
X397 1 1 VIA1_C_CDNS_135 $T=107930 21400 1 180 $X=107430 $Y=15440
X398 1 1 VIA1_C_CDNS_135 $T=107930 41990 1 180 $X=107430 $Y=36030
X399 1 1 VIA1_C_CDNS_135 $T=107930 62580 1 180 $X=107430 $Y=56620
X400 3 1 VIA1_C_CDNS_135 $T=109530 21400 1 180 $X=109030 $Y=15440
X401 3 1 VIA1_C_CDNS_135 $T=109530 41990 1 180 $X=109030 $Y=36030
X402 3 1 VIA1_C_CDNS_135 $T=109530 62580 1 180 $X=109030 $Y=56620
X403 1 1 VIA1_C_CDNS_135 $T=113730 21400 1 180 $X=113230 $Y=15440
X404 1 1 VIA1_C_CDNS_135 $T=113730 41990 1 180 $X=113230 $Y=36030
X405 1 1 VIA1_C_CDNS_135 $T=113730 62580 1 180 $X=113230 $Y=56620
X406 3 1 VIA1_C_CDNS_135 $T=115330 21400 1 180 $X=114830 $Y=15440
X407 3 1 VIA1_C_CDNS_135 $T=115330 41990 1 180 $X=114830 $Y=36030
X408 3 1 VIA1_C_CDNS_135 $T=115330 62580 1 180 $X=114830 $Y=56620
X409 1 1 VIA1_C_CDNS_135 $T=119530 21400 1 180 $X=119030 $Y=15440
X410 1 1 VIA1_C_CDNS_135 $T=119530 41990 1 180 $X=119030 $Y=36030
X411 1 1 VIA1_C_CDNS_135 $T=119530 62580 1 180 $X=119030 $Y=56620
X412 3 1 VIA1_C_CDNS_135 $T=121130 21400 1 180 $X=120630 $Y=15440
X413 3 1 VIA1_C_CDNS_135 $T=121130 41990 1 180 $X=120630 $Y=36030
X414 3 1 VIA1_C_CDNS_135 $T=121130 62580 1 180 $X=120630 $Y=56620
X415 1 1 VIA1_C_CDNS_135 $T=125330 21400 1 180 $X=124830 $Y=15440
X416 1 1 VIA1_C_CDNS_135 $T=125330 41990 1 180 $X=124830 $Y=36030
X417 1 1 VIA1_C_CDNS_135 $T=125330 62580 1 180 $X=124830 $Y=56620
X418 3 1 VIA1_C_CDNS_135 $T=126930 21400 1 180 $X=126430 $Y=15440
X419 3 1 VIA1_C_CDNS_135 $T=126930 41990 1 180 $X=126430 $Y=36030
X420 3 1 VIA1_C_CDNS_135 $T=126930 62580 1 180 $X=126430 $Y=56620
X421 1 1 VIA1_C_CDNS_135 $T=131130 21400 1 180 $X=130630 $Y=15440
X422 1 1 VIA1_C_CDNS_135 $T=131130 41990 1 180 $X=130630 $Y=36030
X423 1 1 VIA1_C_CDNS_135 $T=131130 62580 1 180 $X=130630 $Y=56620
X424 3 1 VIA1_C_CDNS_135 $T=132730 21400 1 180 $X=132230 $Y=15440
X425 3 1 VIA1_C_CDNS_135 $T=132730 41990 1 180 $X=132230 $Y=36030
X426 3 1 VIA1_C_CDNS_135 $T=132730 62580 1 180 $X=132230 $Y=56620
X427 1 1 VIA1_C_CDNS_135 $T=136930 21400 1 180 $X=136430 $Y=15440
X428 1 1 VIA1_C_CDNS_135 $T=136930 41990 1 180 $X=136430 $Y=36030
X429 1 1 VIA1_C_CDNS_135 $T=136930 62580 1 180 $X=136430 $Y=56620
X430 3 1 VIA1_C_CDNS_135 $T=138530 21400 1 180 $X=138030 $Y=15440
X431 3 1 VIA1_C_CDNS_135 $T=138530 41990 1 180 $X=138030 $Y=36030
X432 3 1 VIA1_C_CDNS_135 $T=138530 62580 1 180 $X=138030 $Y=56620
X433 1 1 VIA1_C_CDNS_135 $T=142730 21400 1 180 $X=142230 $Y=15440
X434 1 1 VIA1_C_CDNS_135 $T=142730 41990 1 180 $X=142230 $Y=36030
X435 1 1 VIA1_C_CDNS_135 $T=142730 62580 1 180 $X=142230 $Y=56620
X436 1 VIA3_C_CDNS_136 $T=16730 30475 0 0 $X=16240 $Y=29205
X437 1 VIA3_C_CDNS_136 $T=16730 51065 0 0 $X=16240 $Y=49795
X438 3 VIA3_C_CDNS_136 $T=20930 33755 0 0 $X=20440 $Y=32485
X439 3 VIA3_C_CDNS_136 $T=20930 54345 0 0 $X=20440 $Y=53075
X440 1 VIA3_C_CDNS_136 $T=22530 30475 0 0 $X=22040 $Y=29205
X441 1 VIA3_C_CDNS_136 $T=22530 51065 0 0 $X=22040 $Y=49795
X442 3 VIA3_C_CDNS_136 $T=26730 33755 0 0 $X=26240 $Y=32485
X443 3 VIA3_C_CDNS_136 $T=26730 54345 0 0 $X=26240 $Y=53075
X444 1 VIA3_C_CDNS_136 $T=28330 30475 0 0 $X=27840 $Y=29205
X445 1 VIA3_C_CDNS_136 $T=28330 51065 0 0 $X=27840 $Y=49795
X446 3 VIA3_C_CDNS_136 $T=32530 33755 0 0 $X=32040 $Y=32485
X447 3 VIA3_C_CDNS_136 $T=32530 54345 0 0 $X=32040 $Y=53075
X448 1 VIA3_C_CDNS_136 $T=34130 30475 0 0 $X=33640 $Y=29205
X449 1 VIA3_C_CDNS_136 $T=34130 51065 0 0 $X=33640 $Y=49795
X450 3 VIA3_C_CDNS_136 $T=38330 33755 0 0 $X=37840 $Y=32485
X451 3 VIA3_C_CDNS_136 $T=38330 54345 0 0 $X=37840 $Y=53075
X452 1 VIA3_C_CDNS_136 $T=39930 30475 0 0 $X=39440 $Y=29205
X453 1 VIA3_C_CDNS_136 $T=39930 51065 0 0 $X=39440 $Y=49795
X454 3 VIA3_C_CDNS_136 $T=44130 33755 0 0 $X=43640 $Y=32485
X455 3 VIA3_C_CDNS_136 $T=44130 54345 0 0 $X=43640 $Y=53075
X456 1 VIA3_C_CDNS_136 $T=45730 30475 0 0 $X=45240 $Y=29205
X457 1 VIA3_C_CDNS_136 $T=45730 51065 0 0 $X=45240 $Y=49795
X458 3 VIA3_C_CDNS_136 $T=49930 33755 0 0 $X=49440 $Y=32485
X459 3 VIA3_C_CDNS_136 $T=49930 54345 0 0 $X=49440 $Y=53075
X460 1 VIA3_C_CDNS_136 $T=51530 30475 0 0 $X=51040 $Y=29205
X461 1 VIA3_C_CDNS_136 $T=51530 51065 0 0 $X=51040 $Y=49795
X462 3 VIA3_C_CDNS_136 $T=55730 33755 0 0 $X=55240 $Y=32485
X463 3 VIA3_C_CDNS_136 $T=55730 54345 0 0 $X=55240 $Y=53075
X464 1 VIA3_C_CDNS_136 $T=57330 30475 0 0 $X=56840 $Y=29205
X465 1 VIA3_C_CDNS_136 $T=57330 51065 0 0 $X=56840 $Y=49795
X466 3 VIA3_C_CDNS_136 $T=61530 33755 0 0 $X=61040 $Y=32485
X467 3 VIA3_C_CDNS_136 $T=61530 54345 0 0 $X=61040 $Y=53075
X468 1 VIA3_C_CDNS_136 $T=63130 30475 0 0 $X=62640 $Y=29205
X469 1 VIA3_C_CDNS_136 $T=63130 51065 0 0 $X=62640 $Y=49795
X470 3 VIA3_C_CDNS_136 $T=67330 33755 0 0 $X=66840 $Y=32485
X471 3 VIA3_C_CDNS_136 $T=67330 54345 0 0 $X=66840 $Y=53075
X472 1 VIA3_C_CDNS_136 $T=68930 30475 0 0 $X=68440 $Y=29205
X473 1 VIA3_C_CDNS_136 $T=68930 51065 0 0 $X=68440 $Y=49795
X474 3 VIA3_C_CDNS_136 $T=73130 33755 0 0 $X=72640 $Y=32485
X475 1 VIA3_C_CDNS_136 $T=74730 30475 0 0 $X=74240 $Y=29205
X476 1 VIA3_C_CDNS_136 $T=74730 51065 0 0 $X=74240 $Y=49795
X477 3 VIA3_C_CDNS_136 $T=78930 54345 0 0 $X=78440 $Y=53075
X478 1 VIA3_C_CDNS_136 $T=80530 30475 0 0 $X=80040 $Y=29205
X479 1 VIA3_C_CDNS_136 $T=80530 51065 0 0 $X=80040 $Y=49795
X480 3 VIA3_C_CDNS_136 $T=84730 54345 0 0 $X=84240 $Y=53075
X481 3 VIA3_C_CDNS_136 $T=86330 33755 1 180 $X=85840 $Y=32485
X482 1 VIA3_C_CDNS_136 $T=90530 30475 1 180 $X=90040 $Y=29205
X483 1 VIA3_C_CDNS_136 $T=90530 51065 1 180 $X=90040 $Y=49795
X484 3 VIA3_C_CDNS_136 $T=92130 33755 1 180 $X=91640 $Y=32485
X485 3 VIA3_C_CDNS_136 $T=92130 54345 1 180 $X=91640 $Y=53075
X486 1 VIA3_C_CDNS_136 $T=96330 30475 1 180 $X=95840 $Y=29205
X487 1 VIA3_C_CDNS_136 $T=96330 51065 1 180 $X=95840 $Y=49795
X488 3 VIA3_C_CDNS_136 $T=97930 33755 1 180 $X=97440 $Y=32485
X489 3 VIA3_C_CDNS_136 $T=97930 54345 1 180 $X=97440 $Y=53075
X490 1 VIA3_C_CDNS_136 $T=102130 30475 1 180 $X=101640 $Y=29205
X491 1 VIA3_C_CDNS_136 $T=102130 51065 1 180 $X=101640 $Y=49795
X492 3 VIA3_C_CDNS_136 $T=103730 33755 1 180 $X=103240 $Y=32485
X493 3 VIA3_C_CDNS_136 $T=103730 54345 1 180 $X=103240 $Y=53075
X494 1 VIA3_C_CDNS_136 $T=107930 30475 1 180 $X=107440 $Y=29205
X495 1 VIA3_C_CDNS_136 $T=107930 51065 1 180 $X=107440 $Y=49795
X496 3 VIA3_C_CDNS_136 $T=109530 33755 1 180 $X=109040 $Y=32485
X497 3 VIA3_C_CDNS_136 $T=109530 54345 1 180 $X=109040 $Y=53075
X498 1 VIA3_C_CDNS_136 $T=113730 30475 1 180 $X=113240 $Y=29205
X499 1 VIA3_C_CDNS_136 $T=113730 51065 1 180 $X=113240 $Y=49795
X500 3 VIA3_C_CDNS_136 $T=115330 33755 1 180 $X=114840 $Y=32485
X501 3 VIA3_C_CDNS_136 $T=115330 54345 1 180 $X=114840 $Y=53075
X502 1 VIA3_C_CDNS_136 $T=119530 30475 1 180 $X=119040 $Y=29205
X503 1 VIA3_C_CDNS_136 $T=119530 51065 1 180 $X=119040 $Y=49795
X504 3 VIA3_C_CDNS_136 $T=121130 33755 1 180 $X=120640 $Y=32485
X505 3 VIA3_C_CDNS_136 $T=121130 54345 1 180 $X=120640 $Y=53075
X506 1 VIA3_C_CDNS_136 $T=125330 30475 1 180 $X=124840 $Y=29205
X507 1 VIA3_C_CDNS_136 $T=125330 51065 1 180 $X=124840 $Y=49795
X508 3 VIA3_C_CDNS_136 $T=126930 33755 1 180 $X=126440 $Y=32485
X509 3 VIA3_C_CDNS_136 $T=126930 54345 1 180 $X=126440 $Y=53075
X510 1 VIA3_C_CDNS_136 $T=131130 30475 1 180 $X=130640 $Y=29205
X511 1 VIA3_C_CDNS_136 $T=131130 51065 1 180 $X=130640 $Y=49795
X512 3 VIA3_C_CDNS_136 $T=132730 33755 1 180 $X=132240 $Y=32485
X513 3 VIA3_C_CDNS_136 $T=132730 54345 1 180 $X=132240 $Y=53075
X514 1 VIA3_C_CDNS_136 $T=136930 30475 1 180 $X=136440 $Y=29205
X515 1 VIA3_C_CDNS_136 $T=136930 51065 1 180 $X=136440 $Y=49795
X516 3 VIA3_C_CDNS_136 $T=138530 33755 1 180 $X=138040 $Y=32485
X517 3 VIA3_C_CDNS_136 $T=138530 54345 1 180 $X=138040 $Y=53075
X518 1 VIA3_C_CDNS_136 $T=142730 30475 1 180 $X=142240 $Y=29205
X519 1 VIA3_C_CDNS_136 $T=142730 51065 1 180 $X=142240 $Y=49795
X520 1 VIA3_C_CDNS_137 $T=16730 6125 0 0 $X=16240 $Y=3815
X521 3 VIA3_C_CDNS_137 $T=20930 11405 0 0 $X=20440 $Y=9095
X522 1 VIA3_C_CDNS_137 $T=22530 6125 0 0 $X=22040 $Y=3815
X523 3 VIA3_C_CDNS_137 $T=26730 11405 0 0 $X=26240 $Y=9095
X524 1 VIA3_C_CDNS_137 $T=28330 6125 0 0 $X=27840 $Y=3815
X525 3 VIA3_C_CDNS_137 $T=32530 11405 0 0 $X=32040 $Y=9095
X526 1 VIA3_C_CDNS_137 $T=34130 6125 0 0 $X=33640 $Y=3815
X527 3 VIA3_C_CDNS_137 $T=38330 11405 0 0 $X=37840 $Y=9095
X528 1 VIA3_C_CDNS_137 $T=39930 6125 0 0 $X=39440 $Y=3815
X529 3 VIA3_C_CDNS_137 $T=44130 11405 0 0 $X=43640 $Y=9095
X530 1 VIA3_C_CDNS_137 $T=45730 6125 0 0 $X=45240 $Y=3815
X531 3 VIA3_C_CDNS_137 $T=49930 11405 0 0 $X=49440 $Y=9095
X532 1 VIA3_C_CDNS_137 $T=51530 6125 0 0 $X=51040 $Y=3815
X533 3 VIA3_C_CDNS_137 $T=55730 11405 0 0 $X=55240 $Y=9095
X534 1 VIA3_C_CDNS_137 $T=57330 6125 0 0 $X=56840 $Y=3815
X535 3 VIA3_C_CDNS_137 $T=61530 11405 0 0 $X=61040 $Y=9095
X536 1 VIA3_C_CDNS_137 $T=63130 6125 0 0 $X=62640 $Y=3815
X537 3 VIA3_C_CDNS_137 $T=67330 11405 0 0 $X=66840 $Y=9095
X538 1 VIA3_C_CDNS_137 $T=68930 6125 0 0 $X=68440 $Y=3815
X539 1 VIA3_C_CDNS_137 $T=74730 6125 0 0 $X=74240 $Y=3815
X540 3 VIA3_C_CDNS_137 $T=78930 11405 0 0 $X=78440 $Y=9095
X541 1 VIA3_C_CDNS_137 $T=80530 6125 0 0 $X=80040 $Y=3815
X542 3 VIA3_C_CDNS_137 $T=84730 11405 0 0 $X=84240 $Y=9095
X543 1 VIA3_C_CDNS_137 $T=90530 6125 1 180 $X=90040 $Y=3815
X544 3 VIA3_C_CDNS_137 $T=92130 11405 1 180 $X=91640 $Y=9095
X545 1 VIA3_C_CDNS_137 $T=96330 6125 1 180 $X=95840 $Y=3815
X546 3 VIA3_C_CDNS_137 $T=97930 11405 1 180 $X=97440 $Y=9095
X547 1 VIA3_C_CDNS_137 $T=102130 6125 1 180 $X=101640 $Y=3815
X548 3 VIA3_C_CDNS_137 $T=103730 11405 1 180 $X=103240 $Y=9095
X549 1 VIA3_C_CDNS_137 $T=107930 6125 1 180 $X=107440 $Y=3815
X550 3 VIA3_C_CDNS_137 $T=109530 11405 1 180 $X=109040 $Y=9095
X551 1 VIA3_C_CDNS_137 $T=113730 6125 1 180 $X=113240 $Y=3815
X552 3 VIA3_C_CDNS_137 $T=115330 11405 1 180 $X=114840 $Y=9095
X553 1 VIA3_C_CDNS_137 $T=119530 6125 1 180 $X=119040 $Y=3815
X554 3 VIA3_C_CDNS_137 $T=121130 11405 1 180 $X=120640 $Y=9095
X555 1 VIA3_C_CDNS_137 $T=125330 6125 1 180 $X=124840 $Y=3815
X556 3 VIA3_C_CDNS_137 $T=126930 11405 1 180 $X=126440 $Y=9095
X557 1 VIA3_C_CDNS_137 $T=131130 6125 1 180 $X=130640 $Y=3815
X558 3 VIA3_C_CDNS_137 $T=132730 11405 1 180 $X=132240 $Y=9095
X559 1 VIA3_C_CDNS_137 $T=136930 6125 1 180 $X=136440 $Y=3815
X560 3 VIA3_C_CDNS_137 $T=138530 11405 1 180 $X=138040 $Y=9095
X561 1 VIA3_C_CDNS_137 $T=142730 6125 1 180 $X=142240 $Y=3815
X562 1 VIA2_C_CDNS_138 $T=16730 6125 0 0 $X=16240 $Y=3815
X563 3 VIA2_C_CDNS_138 $T=20930 11405 0 0 $X=20440 $Y=9095
X564 1 VIA2_C_CDNS_138 $T=22530 6125 0 0 $X=22040 $Y=3815
X565 3 VIA2_C_CDNS_138 $T=26730 11405 0 0 $X=26240 $Y=9095
X566 1 VIA2_C_CDNS_138 $T=28330 6125 0 0 $X=27840 $Y=3815
X567 3 VIA2_C_CDNS_138 $T=32530 11405 0 0 $X=32040 $Y=9095
X568 1 VIA2_C_CDNS_138 $T=34130 6125 0 0 $X=33640 $Y=3815
X569 3 VIA2_C_CDNS_138 $T=38330 11405 0 0 $X=37840 $Y=9095
X570 1 VIA2_C_CDNS_138 $T=39930 6125 0 0 $X=39440 $Y=3815
X571 3 VIA2_C_CDNS_138 $T=44130 11405 0 0 $X=43640 $Y=9095
X572 1 VIA2_C_CDNS_138 $T=45730 6125 0 0 $X=45240 $Y=3815
X573 3 VIA2_C_CDNS_138 $T=49930 11405 0 0 $X=49440 $Y=9095
X574 1 VIA2_C_CDNS_138 $T=51530 6125 0 0 $X=51040 $Y=3815
X575 3 VIA2_C_CDNS_138 $T=55730 11405 0 0 $X=55240 $Y=9095
X576 1 VIA2_C_CDNS_138 $T=57330 6125 0 0 $X=56840 $Y=3815
X577 3 VIA2_C_CDNS_138 $T=61530 11405 0 0 $X=61040 $Y=9095
X578 1 VIA2_C_CDNS_138 $T=63130 6125 0 0 $X=62640 $Y=3815
X579 3 VIA2_C_CDNS_138 $T=67330 11405 0 0 $X=66840 $Y=9095
X580 1 VIA2_C_CDNS_138 $T=68930 6125 0 0 $X=68440 $Y=3815
X581 1 VIA2_C_CDNS_138 $T=74730 6125 0 0 $X=74240 $Y=3815
X582 3 VIA2_C_CDNS_138 $T=78930 11405 0 0 $X=78440 $Y=9095
X583 1 VIA2_C_CDNS_138 $T=80530 6125 0 0 $X=80040 $Y=3815
X584 3 VIA2_C_CDNS_138 $T=84730 11405 0 0 $X=84240 $Y=9095
X585 1 VIA2_C_CDNS_138 $T=90530 6125 1 180 $X=90040 $Y=3815
X586 3 VIA2_C_CDNS_138 $T=92130 11405 1 180 $X=91640 $Y=9095
X587 1 VIA2_C_CDNS_138 $T=96330 6125 1 180 $X=95840 $Y=3815
X588 3 VIA2_C_CDNS_138 $T=97930 11405 1 180 $X=97440 $Y=9095
X589 1 VIA2_C_CDNS_138 $T=102130 6125 1 180 $X=101640 $Y=3815
X590 3 VIA2_C_CDNS_138 $T=103730 11405 1 180 $X=103240 $Y=9095
X591 1 VIA2_C_CDNS_138 $T=107930 6125 1 180 $X=107440 $Y=3815
X592 3 VIA2_C_CDNS_138 $T=109530 11405 1 180 $X=109040 $Y=9095
X593 1 VIA2_C_CDNS_138 $T=113730 6125 1 180 $X=113240 $Y=3815
X594 3 VIA2_C_CDNS_138 $T=115330 11405 1 180 $X=114840 $Y=9095
X595 1 VIA2_C_CDNS_138 $T=119530 6125 1 180 $X=119040 $Y=3815
X596 3 VIA2_C_CDNS_138 $T=121130 11405 1 180 $X=120640 $Y=9095
X597 1 VIA2_C_CDNS_138 $T=125330 6125 1 180 $X=124840 $Y=3815
X598 3 VIA2_C_CDNS_138 $T=126930 11405 1 180 $X=126440 $Y=9095
X599 1 VIA2_C_CDNS_138 $T=131130 6125 1 180 $X=130640 $Y=3815
X600 3 VIA2_C_CDNS_138 $T=132730 11405 1 180 $X=132240 $Y=9095
X601 1 VIA2_C_CDNS_138 $T=136930 6125 1 180 $X=136440 $Y=3815
X602 3 VIA2_C_CDNS_138 $T=138530 11405 1 180 $X=138040 $Y=9095
X603 1 VIA2_C_CDNS_138 $T=142730 6125 1 180 $X=142240 $Y=3815
X604 1 VIA1_C_CDNS_139 $T=16730 6125 0 0 $X=16240 $Y=3815
X605 3 VIA1_C_CDNS_139 $T=20930 11405 0 0 $X=20440 $Y=9095
X606 1 VIA1_C_CDNS_139 $T=22530 6125 0 0 $X=22040 $Y=3815
X607 3 VIA1_C_CDNS_139 $T=26730 11405 0 0 $X=26240 $Y=9095
X608 1 VIA1_C_CDNS_139 $T=28330 6125 0 0 $X=27840 $Y=3815
X609 3 VIA1_C_CDNS_139 $T=32530 11405 0 0 $X=32040 $Y=9095
X610 1 VIA1_C_CDNS_139 $T=34130 6125 0 0 $X=33640 $Y=3815
X611 3 VIA1_C_CDNS_139 $T=38330 11405 0 0 $X=37840 $Y=9095
X612 1 VIA1_C_CDNS_139 $T=39930 6125 0 0 $X=39440 $Y=3815
X613 3 VIA1_C_CDNS_139 $T=44130 11405 0 0 $X=43640 $Y=9095
X614 1 VIA1_C_CDNS_139 $T=45730 6125 0 0 $X=45240 $Y=3815
X615 3 VIA1_C_CDNS_139 $T=49930 11405 0 0 $X=49440 $Y=9095
X616 1 VIA1_C_CDNS_139 $T=51530 6125 0 0 $X=51040 $Y=3815
X617 3 VIA1_C_CDNS_139 $T=55730 11405 0 0 $X=55240 $Y=9095
X618 1 VIA1_C_CDNS_139 $T=57330 6125 0 0 $X=56840 $Y=3815
X619 3 VIA1_C_CDNS_139 $T=61530 11405 0 0 $X=61040 $Y=9095
X620 1 VIA1_C_CDNS_139 $T=63130 6125 0 0 $X=62640 $Y=3815
X621 3 VIA1_C_CDNS_139 $T=67330 11405 0 0 $X=66840 $Y=9095
X622 1 VIA1_C_CDNS_139 $T=68930 6125 0 0 $X=68440 $Y=3815
X623 1 VIA1_C_CDNS_139 $T=74730 6125 0 0 $X=74240 $Y=3815
X624 3 VIA1_C_CDNS_139 $T=78930 11405 0 0 $X=78440 $Y=9095
X625 1 VIA1_C_CDNS_139 $T=80530 6125 0 0 $X=80040 $Y=3815
X626 3 VIA1_C_CDNS_139 $T=84730 11405 0 0 $X=84240 $Y=9095
X627 1 VIA1_C_CDNS_139 $T=90530 6125 1 180 $X=90040 $Y=3815
X628 3 VIA1_C_CDNS_139 $T=92130 11405 1 180 $X=91640 $Y=9095
X629 1 VIA1_C_CDNS_139 $T=96330 6125 1 180 $X=95840 $Y=3815
X630 3 VIA1_C_CDNS_139 $T=97930 11405 1 180 $X=97440 $Y=9095
X631 1 VIA1_C_CDNS_139 $T=102130 6125 1 180 $X=101640 $Y=3815
X632 3 VIA1_C_CDNS_139 $T=103730 11405 1 180 $X=103240 $Y=9095
X633 1 VIA1_C_CDNS_139 $T=107930 6125 1 180 $X=107440 $Y=3815
X634 3 VIA1_C_CDNS_139 $T=109530 11405 1 180 $X=109040 $Y=9095
X635 1 VIA1_C_CDNS_139 $T=113730 6125 1 180 $X=113240 $Y=3815
X636 3 VIA1_C_CDNS_139 $T=115330 11405 1 180 $X=114840 $Y=9095
X637 1 VIA1_C_CDNS_139 $T=119530 6125 1 180 $X=119040 $Y=3815
X638 3 VIA1_C_CDNS_139 $T=121130 11405 1 180 $X=120640 $Y=9095
X639 1 VIA1_C_CDNS_139 $T=125330 6125 1 180 $X=124840 $Y=3815
X640 3 VIA1_C_CDNS_139 $T=126930 11405 1 180 $X=126440 $Y=9095
X641 1 VIA1_C_CDNS_139 $T=131130 6125 1 180 $X=130640 $Y=3815
X642 3 VIA1_C_CDNS_139 $T=132730 11405 1 180 $X=132240 $Y=9095
X643 1 VIA1_C_CDNS_139 $T=136930 6125 1 180 $X=136440 $Y=3815
X644 3 VIA1_C_CDNS_139 $T=138530 11405 1 180 $X=138040 $Y=9095
X645 1 VIA1_C_CDNS_139 $T=142730 6125 1 180 $X=142240 $Y=3815
X646 1 VIA1_C_CDNS_140 $T=16730 30475 0 0 $X=16240 $Y=29205
X647 1 VIA1_C_CDNS_140 $T=16730 51065 0 0 $X=16240 $Y=49795
X648 3 VIA1_C_CDNS_140 $T=20930 33755 0 0 $X=20440 $Y=32485
X649 3 VIA1_C_CDNS_140 $T=20930 54345 0 0 $X=20440 $Y=53075
X650 1 VIA1_C_CDNS_140 $T=22530 30475 0 0 $X=22040 $Y=29205
X651 1 VIA1_C_CDNS_140 $T=22530 51065 0 0 $X=22040 $Y=49795
X652 3 VIA1_C_CDNS_140 $T=26730 33755 0 0 $X=26240 $Y=32485
X653 3 VIA1_C_CDNS_140 $T=26730 54345 0 0 $X=26240 $Y=53075
X654 1 VIA1_C_CDNS_140 $T=28330 30475 0 0 $X=27840 $Y=29205
X655 1 VIA1_C_CDNS_140 $T=28330 51065 0 0 $X=27840 $Y=49795
X656 3 VIA1_C_CDNS_140 $T=32530 33755 0 0 $X=32040 $Y=32485
X657 3 VIA1_C_CDNS_140 $T=32530 54345 0 0 $X=32040 $Y=53075
X658 1 VIA1_C_CDNS_140 $T=34130 30475 0 0 $X=33640 $Y=29205
X659 1 VIA1_C_CDNS_140 $T=34130 51065 0 0 $X=33640 $Y=49795
X660 3 VIA1_C_CDNS_140 $T=38330 33755 0 0 $X=37840 $Y=32485
X661 3 VIA1_C_CDNS_140 $T=38330 54345 0 0 $X=37840 $Y=53075
X662 1 VIA1_C_CDNS_140 $T=39930 30475 0 0 $X=39440 $Y=29205
X663 1 VIA1_C_CDNS_140 $T=39930 51065 0 0 $X=39440 $Y=49795
X664 3 VIA1_C_CDNS_140 $T=44130 33755 0 0 $X=43640 $Y=32485
X665 3 VIA1_C_CDNS_140 $T=44130 54345 0 0 $X=43640 $Y=53075
X666 1 VIA1_C_CDNS_140 $T=45730 30475 0 0 $X=45240 $Y=29205
X667 1 VIA1_C_CDNS_140 $T=45730 51065 0 0 $X=45240 $Y=49795
X668 3 VIA1_C_CDNS_140 $T=49930 33755 0 0 $X=49440 $Y=32485
X669 3 VIA1_C_CDNS_140 $T=49930 54345 0 0 $X=49440 $Y=53075
X670 1 VIA1_C_CDNS_140 $T=51530 30475 0 0 $X=51040 $Y=29205
X671 1 VIA1_C_CDNS_140 $T=51530 51065 0 0 $X=51040 $Y=49795
X672 3 VIA1_C_CDNS_140 $T=55730 33755 0 0 $X=55240 $Y=32485
X673 3 VIA1_C_CDNS_140 $T=55730 54345 0 0 $X=55240 $Y=53075
X674 1 VIA1_C_CDNS_140 $T=57330 30475 0 0 $X=56840 $Y=29205
X675 1 VIA1_C_CDNS_140 $T=57330 51065 0 0 $X=56840 $Y=49795
X676 3 VIA1_C_CDNS_140 $T=61530 33755 0 0 $X=61040 $Y=32485
X677 3 VIA1_C_CDNS_140 $T=61530 54345 0 0 $X=61040 $Y=53075
X678 1 VIA1_C_CDNS_140 $T=63130 30475 0 0 $X=62640 $Y=29205
X679 1 VIA1_C_CDNS_140 $T=63130 51065 0 0 $X=62640 $Y=49795
X680 3 VIA1_C_CDNS_140 $T=67330 33755 0 0 $X=66840 $Y=32485
X681 3 VIA1_C_CDNS_140 $T=67330 54345 0 0 $X=66840 $Y=53075
X682 1 VIA1_C_CDNS_140 $T=68930 30475 0 0 $X=68440 $Y=29205
X683 1 VIA1_C_CDNS_140 $T=68930 51065 0 0 $X=68440 $Y=49795
X684 3 VIA1_C_CDNS_140 $T=73130 33755 0 0 $X=72640 $Y=32485
X685 1 VIA1_C_CDNS_140 $T=74730 30475 0 0 $X=74240 $Y=29205
X686 1 VIA1_C_CDNS_140 $T=74730 51065 0 0 $X=74240 $Y=49795
X687 3 VIA1_C_CDNS_140 $T=78930 54345 0 0 $X=78440 $Y=53075
X688 1 VIA1_C_CDNS_140 $T=80530 30475 0 0 $X=80040 $Y=29205
X689 1 VIA1_C_CDNS_140 $T=80530 51065 0 0 $X=80040 $Y=49795
X690 3 VIA1_C_CDNS_140 $T=84730 54345 0 0 $X=84240 $Y=53075
X691 3 VIA1_C_CDNS_140 $T=86330 33755 1 180 $X=85840 $Y=32485
X692 1 VIA1_C_CDNS_140 $T=90530 30475 1 180 $X=90040 $Y=29205
X693 1 VIA1_C_CDNS_140 $T=90530 51065 1 180 $X=90040 $Y=49795
X694 3 VIA1_C_CDNS_140 $T=92130 33755 1 180 $X=91640 $Y=32485
X695 3 VIA1_C_CDNS_140 $T=92130 54345 1 180 $X=91640 $Y=53075
X696 1 VIA1_C_CDNS_140 $T=96330 30475 1 180 $X=95840 $Y=29205
X697 1 VIA1_C_CDNS_140 $T=96330 51065 1 180 $X=95840 $Y=49795
X698 3 VIA1_C_CDNS_140 $T=97930 33755 1 180 $X=97440 $Y=32485
X699 3 VIA1_C_CDNS_140 $T=97930 54345 1 180 $X=97440 $Y=53075
X700 1 VIA1_C_CDNS_140 $T=102130 30475 1 180 $X=101640 $Y=29205
X701 1 VIA1_C_CDNS_140 $T=102130 51065 1 180 $X=101640 $Y=49795
X702 3 VIA1_C_CDNS_140 $T=103730 33755 1 180 $X=103240 $Y=32485
X703 3 VIA1_C_CDNS_140 $T=103730 54345 1 180 $X=103240 $Y=53075
X704 1 VIA1_C_CDNS_140 $T=107930 30475 1 180 $X=107440 $Y=29205
X705 1 VIA1_C_CDNS_140 $T=107930 51065 1 180 $X=107440 $Y=49795
X706 3 VIA1_C_CDNS_140 $T=109530 33755 1 180 $X=109040 $Y=32485
X707 3 VIA1_C_CDNS_140 $T=109530 54345 1 180 $X=109040 $Y=53075
X708 1 VIA1_C_CDNS_140 $T=113730 30475 1 180 $X=113240 $Y=29205
X709 1 VIA1_C_CDNS_140 $T=113730 51065 1 180 $X=113240 $Y=49795
X710 3 VIA1_C_CDNS_140 $T=115330 33755 1 180 $X=114840 $Y=32485
X711 3 VIA1_C_CDNS_140 $T=115330 54345 1 180 $X=114840 $Y=53075
X712 1 VIA1_C_CDNS_140 $T=119530 30475 1 180 $X=119040 $Y=29205
X713 1 VIA1_C_CDNS_140 $T=119530 51065 1 180 $X=119040 $Y=49795
X714 3 VIA1_C_CDNS_140 $T=121130 33755 1 180 $X=120640 $Y=32485
X715 3 VIA1_C_CDNS_140 $T=121130 54345 1 180 $X=120640 $Y=53075
X716 1 VIA1_C_CDNS_140 $T=125330 30475 1 180 $X=124840 $Y=29205
X717 1 VIA1_C_CDNS_140 $T=125330 51065 1 180 $X=124840 $Y=49795
X718 3 VIA1_C_CDNS_140 $T=126930 33755 1 180 $X=126440 $Y=32485
X719 3 VIA1_C_CDNS_140 $T=126930 54345 1 180 $X=126440 $Y=53075
X720 1 VIA1_C_CDNS_140 $T=131130 30475 1 180 $X=130640 $Y=29205
X721 1 VIA1_C_CDNS_140 $T=131130 51065 1 180 $X=130640 $Y=49795
X722 3 VIA1_C_CDNS_140 $T=132730 33755 1 180 $X=132240 $Y=32485
X723 3 VIA1_C_CDNS_140 $T=132730 54345 1 180 $X=132240 $Y=53075
X724 1 VIA1_C_CDNS_140 $T=136930 30475 1 180 $X=136440 $Y=29205
X725 1 VIA1_C_CDNS_140 $T=136930 51065 1 180 $X=136440 $Y=49795
X726 3 VIA1_C_CDNS_140 $T=138530 33755 1 180 $X=138040 $Y=32485
X727 3 VIA1_C_CDNS_140 $T=138530 54345 1 180 $X=138040 $Y=53075
X728 1 VIA1_C_CDNS_140 $T=142730 30475 1 180 $X=142240 $Y=29205
X729 1 VIA1_C_CDNS_140 $T=142730 51065 1 180 $X=142240 $Y=49795
X730 1 VIA3_C_CDNS_141 $T=3310 6160 0 0 $X=3080 $Y=3850
X731 1 VIA3_C_CDNS_141 $T=3310 77990 0 0 $X=3080 $Y=75680
X732 1 VIA3_C_CDNS_141 $T=156150 6160 0 0 $X=155920 $Y=3850
X733 1 VIA3_C_CDNS_141 $T=156150 77990 0 0 $X=155920 $Y=75680
X734 1 VIA1_C_CDNS_142 $T=3310 6160 0 0 $X=3080 $Y=3850
X735 1 VIA1_C_CDNS_142 $T=3310 77990 0 0 $X=3080 $Y=75680
X736 1 VIA1_C_CDNS_142 $T=156150 6160 0 0 $X=155920 $Y=3850
X737 1 VIA1_C_CDNS_142 $T=156150 77990 0 0 $X=155920 $Y=75680
X738 1 VIA3_C_CDNS_143 $T=3310 30530 0 0 $X=3080 $Y=29260
X739 1 VIA3_C_CDNS_143 $T=3310 51120 0 0 $X=3080 $Y=49850
X740 1 VIA3_C_CDNS_143 $T=156150 30530 0 0 $X=155920 $Y=29260
X741 1 VIA3_C_CDNS_143 $T=156150 51120 0 0 $X=155920 $Y=49850
X742 1 VIA2_C_CDNS_144 $T=3310 30530 0 0 $X=3080 $Y=29260
X743 1 VIA2_C_CDNS_144 $T=3310 51120 0 0 $X=3080 $Y=49850
X744 1 VIA2_C_CDNS_144 $T=156150 30530 0 0 $X=155920 $Y=29260
X745 1 VIA2_C_CDNS_144 $T=156150 51120 0 0 $X=155920 $Y=49850
X746 1 VIA1_C_CDNS_145 $T=3310 30530 0 0 $X=3080 $Y=29260
X747 1 VIA1_C_CDNS_145 $T=3310 51120 0 0 $X=3080 $Y=49850
X748 1 VIA1_C_CDNS_145 $T=156150 30530 0 0 $X=155920 $Y=29260
X749 1 VIA1_C_CDNS_145 $T=156150 51120 0 0 $X=155920 $Y=49850
X750 1 VIA2_C_CDNS_146 $T=6670 2800 0 0 $X=4360 $Y=2570
X751 1 VIA2_C_CDNS_146 $T=6670 81350 0 0 $X=4360 $Y=81120
X752 1 VIA2_C_CDNS_146 $T=152790 2800 0 0 $X=150480 $Y=2570
X753 1 VIA2_C_CDNS_146 $T=152790 81350 0 0 $X=150480 $Y=81120
X754 1 VIA1_C_CDNS_147 $T=6670 2800 0 0 $X=4360 $Y=2570
X755 1 VIA1_C_CDNS_147 $T=6670 81350 0 0 $X=4360 $Y=81120
X756 1 VIA1_C_CDNS_147 $T=152790 2800 0 0 $X=150480 $Y=2570
X757 1 VIA1_C_CDNS_147 $T=152790 81350 0 0 $X=150480 $Y=81120
X758 1 2 3 ne3_CDNS_148 $T=17330 15400 0 0 $X=16530 $Y=15000
X759 1 2 3 ne3_CDNS_148 $T=17330 35990 0 0 $X=16530 $Y=35590
X760 1 2 3 ne3_CDNS_148 $T=17330 56580 0 0 $X=16530 $Y=56180
X761 1 2 3 ne3_CDNS_148 $T=23130 15400 0 0 $X=22330 $Y=15000
X762 1 2 3 ne3_CDNS_148 $T=23130 35990 0 0 $X=22330 $Y=35590
X763 1 2 3 ne3_CDNS_148 $T=23130 56580 0 0 $X=22330 $Y=56180
X764 1 2 3 ne3_CDNS_148 $T=28930 15400 0 0 $X=28130 $Y=15000
X765 1 2 3 ne3_CDNS_148 $T=28930 35990 0 0 $X=28130 $Y=35590
X766 1 2 3 ne3_CDNS_148 $T=28930 56580 0 0 $X=28130 $Y=56180
X767 1 2 3 ne3_CDNS_148 $T=34730 15400 0 0 $X=33930 $Y=15000
X768 1 2 3 ne3_CDNS_148 $T=34730 35990 0 0 $X=33930 $Y=35590
X769 1 2 3 ne3_CDNS_148 $T=34730 56580 0 0 $X=33930 $Y=56180
X770 1 2 3 ne3_CDNS_148 $T=40530 15400 0 0 $X=39730 $Y=15000
X771 1 2 3 ne3_CDNS_148 $T=40530 35990 0 0 $X=39730 $Y=35590
X772 1 2 3 ne3_CDNS_148 $T=40530 56580 0 0 $X=39730 $Y=56180
X773 1 2 3 ne3_CDNS_148 $T=46330 15400 0 0 $X=45530 $Y=15000
X774 1 2 3 ne3_CDNS_148 $T=46330 35990 0 0 $X=45530 $Y=35590
X775 1 2 3 ne3_CDNS_148 $T=46330 56580 0 0 $X=45530 $Y=56180
X776 1 2 3 ne3_CDNS_148 $T=52130 15400 0 0 $X=51330 $Y=15000
X777 1 2 3 ne3_CDNS_148 $T=52130 35990 0 0 $X=51330 $Y=35590
X778 1 2 3 ne3_CDNS_148 $T=52130 56580 0 0 $X=51330 $Y=56180
X779 1 2 3 ne3_CDNS_148 $T=57930 15400 0 0 $X=57130 $Y=15000
X780 1 2 3 ne3_CDNS_148 $T=57930 35990 0 0 $X=57130 $Y=35590
X781 1 2 3 ne3_CDNS_148 $T=57930 56580 0 0 $X=57130 $Y=56180
X782 1 2 3 ne3_CDNS_148 $T=63730 15400 0 0 $X=62930 $Y=15000
X783 1 2 3 ne3_CDNS_148 $T=63730 35990 0 0 $X=62930 $Y=35590
X784 1 2 3 ne3_CDNS_148 $T=63730 56580 0 0 $X=62930 $Y=56180
X785 1 2 2 ne3_CDNS_148 $T=69530 15400 0 0 $X=68730 $Y=15000
X786 1 2 3 ne3_CDNS_148 $T=69530 35990 0 0 $X=68730 $Y=35590
X787 1 2 2 ne3_CDNS_148 $T=69530 56580 0 0 $X=68730 $Y=56180
X788 1 2 3 ne3_CDNS_148 $T=75330 15400 0 0 $X=74530 $Y=15000
X789 1 2 2 ne3_CDNS_148 $T=75330 35990 0 0 $X=74530 $Y=35590
X790 1 2 3 ne3_CDNS_148 $T=75330 56580 0 0 $X=74530 $Y=56180
X791 1 2 3 ne3_CDNS_148 $T=81130 15400 0 0 $X=80330 $Y=15000
X792 1 2 2 ne3_CDNS_148 $T=81130 35990 0 0 $X=80330 $Y=35590
X793 1 2 3 ne3_CDNS_148 $T=81130 56580 0 0 $X=80330 $Y=56180
X794 1 2 2 ne3_CDNS_148 $T=89930 15400 1 180 $X=86130 $Y=15000
X795 1 2 3 ne3_CDNS_148 $T=89930 35990 1 180 $X=86130 $Y=35590
X796 1 2 2 ne3_CDNS_148 $T=89930 56580 1 180 $X=86130 $Y=56180
X797 1 2 3 ne3_CDNS_148 $T=95730 15400 1 180 $X=91930 $Y=15000
X798 1 2 3 ne3_CDNS_148 $T=95730 35990 1 180 $X=91930 $Y=35590
X799 1 2 3 ne3_CDNS_148 $T=95730 56580 1 180 $X=91930 $Y=56180
X800 1 2 3 ne3_CDNS_148 $T=101530 15400 1 180 $X=97730 $Y=15000
X801 1 2 3 ne3_CDNS_148 $T=101530 35990 1 180 $X=97730 $Y=35590
X802 1 2 3 ne3_CDNS_148 $T=101530 56580 1 180 $X=97730 $Y=56180
X803 1 2 3 ne3_CDNS_148 $T=107330 15400 1 180 $X=103530 $Y=15000
X804 1 2 3 ne3_CDNS_148 $T=107330 35990 1 180 $X=103530 $Y=35590
X805 1 2 3 ne3_CDNS_148 $T=107330 56580 1 180 $X=103530 $Y=56180
X806 1 2 3 ne3_CDNS_148 $T=113130 15400 1 180 $X=109330 $Y=15000
X807 1 2 3 ne3_CDNS_148 $T=113130 35990 1 180 $X=109330 $Y=35590
X808 1 2 3 ne3_CDNS_148 $T=113130 56580 1 180 $X=109330 $Y=56180
X809 1 2 3 ne3_CDNS_148 $T=118930 15400 1 180 $X=115130 $Y=15000
X810 1 2 3 ne3_CDNS_148 $T=118930 35990 1 180 $X=115130 $Y=35590
X811 1 2 3 ne3_CDNS_148 $T=118930 56580 1 180 $X=115130 $Y=56180
X812 1 2 3 ne3_CDNS_148 $T=124730 15400 1 180 $X=120930 $Y=15000
X813 1 2 3 ne3_CDNS_148 $T=124730 35990 1 180 $X=120930 $Y=35590
X814 1 2 3 ne3_CDNS_148 $T=124730 56580 1 180 $X=120930 $Y=56180
X815 1 2 3 ne3_CDNS_148 $T=130530 15400 1 180 $X=126730 $Y=15000
X816 1 2 3 ne3_CDNS_148 $T=130530 35990 1 180 $X=126730 $Y=35590
X817 1 2 3 ne3_CDNS_148 $T=130530 56580 1 180 $X=126730 $Y=56180
X818 1 2 3 ne3_CDNS_148 $T=136330 15400 1 180 $X=132530 $Y=15000
X819 1 2 3 ne3_CDNS_148 $T=136330 35990 1 180 $X=132530 $Y=35590
X820 1 2 3 ne3_CDNS_148 $T=136330 56580 1 180 $X=132530 $Y=56180
X821 1 2 3 ne3_CDNS_148 $T=142130 15400 1 180 $X=138330 $Y=15000
X822 1 2 3 ne3_CDNS_148 $T=142130 35990 1 180 $X=138330 $Y=35590
X823 1 2 3 ne3_CDNS_148 $T=142130 56580 1 180 $X=138330 $Y=56180
.ends CurrentMirror_x10_LV

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_153                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_153 1 2
** N=2 EP=2 FDC=0
.ends VIA2_C_CDNS_153

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIATP_C_CDNS_154                                *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIATP_C_CDNS_154 1 2
** N=2 EP=2 FDC=0
.ends VIATP_C_CDNS_154

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_155                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_155 1 2
** N=2 EP=2 FDC=0
.ends VIA3_C_CDNS_155

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_156                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_156 1 2
** N=2 EP=2 FDC=0
.ends VIA2_C_CDNS_156

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_157                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_157 1 2
** N=2 EP=2 FDC=0
.ends VIA3_C_CDNS_157

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIATP_C_CDNS_158                                *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIATP_C_CDNS_158 1 2
** N=2 EP=2 FDC=0
.ends VIATP_C_CDNS_158

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_160                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_160 1 2
** N=2 EP=2 FDC=0
.ends VIA2_C_CDNS_160

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_161                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_161 1 2
** N=2 EP=2 FDC=0
.ends VIA1_C_CDNS_161

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_162                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_162 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_162

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_164                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_164 1 2
** N=2 EP=2 FDC=0
.ends VIA1_C_CDNS_164

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_165                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_165 1
** N=1 EP=1 FDC=0
.ends VIA3_C_CDNS_165

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIATP_C_CDNS_166                                *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIATP_C_CDNS_166 1
** N=1 EP=1 FDC=0
.ends VIATP_C_CDNS_166

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_167                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_167 1
** N=1 EP=1 FDC=0
.ends VIA3_C_CDNS_167

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIATP_C_CDNS_168                                *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIATP_C_CDNS_168 1
** N=1 EP=1 FDC=0
.ends VIATP_C_CDNS_168

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_169                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_169 1
** N=1 EP=1 FDC=0
.ends VIA3_C_CDNS_169

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIATP_C_CDNS_170                                *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIATP_C_CDNS_170 1
** N=1 EP=1 FDC=0
.ends VIATP_C_CDNS_170

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: M3_MTP_8_cell                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt M3_MTP_8_cell 1 2
** N=2 EP=2 FDC=0
X0 1 VIA3_C_CDNS_165 $T=520 520 0 0 $X=20 $Y=20
X1 1 VIA3_C_CDNS_165 $T=520 2320 0 0 $X=20 $Y=1820
X2 1 VIA3_C_CDNS_165 $T=520 4120 0 0 $X=20 $Y=3620
X3 1 VIA3_C_CDNS_165 $T=520 5920 0 0 $X=20 $Y=5420
X4 1 VIA3_C_CDNS_165 $T=520 7720 0 0 $X=20 $Y=7220
X5 1 VIA3_C_CDNS_165 $T=2320 520 0 0 $X=1820 $Y=20
X6 1 VIA3_C_CDNS_165 $T=2320 2320 0 0 $X=1820 $Y=1820
X7 1 VIA3_C_CDNS_165 $T=2320 4120 0 0 $X=1820 $Y=3620
X8 1 VIA3_C_CDNS_165 $T=2320 5920 0 0 $X=1820 $Y=5420
X9 1 VIA3_C_CDNS_165 $T=2320 7720 0 0 $X=1820 $Y=7220
X10 1 VIA3_C_CDNS_165 $T=4120 520 0 0 $X=3620 $Y=20
X11 1 VIA3_C_CDNS_165 $T=4120 2320 0 0 $X=3620 $Y=1820
X12 1 VIA3_C_CDNS_165 $T=4120 4120 0 0 $X=3620 $Y=3620
X13 1 VIA3_C_CDNS_165 $T=4120 5920 0 0 $X=3620 $Y=5420
X14 1 VIA3_C_CDNS_165 $T=4120 7720 0 0 $X=3620 $Y=7220
X15 1 VIA3_C_CDNS_165 $T=5920 520 0 0 $X=5420 $Y=20
X16 1 VIA3_C_CDNS_165 $T=5920 2320 0 0 $X=5420 $Y=1820
X17 1 VIA3_C_CDNS_165 $T=5920 4120 0 0 $X=5420 $Y=3620
X18 1 VIA3_C_CDNS_165 $T=5920 5920 0 0 $X=5420 $Y=5420
X19 1 VIA3_C_CDNS_165 $T=5920 7720 0 0 $X=5420 $Y=7220
X20 1 VIA3_C_CDNS_165 $T=7720 520 0 0 $X=7220 $Y=20
X21 1 VIA3_C_CDNS_165 $T=7720 2320 0 0 $X=7220 $Y=1820
X22 1 VIA3_C_CDNS_165 $T=7720 4120 0 0 $X=7220 $Y=3620
X23 1 VIA3_C_CDNS_165 $T=7720 5920 0 0 $X=7220 $Y=5420
X24 1 VIA3_C_CDNS_165 $T=7720 7720 0 0 $X=7220 $Y=7220
X25 1 VIATP_C_CDNS_166 $T=520 520 0 0 $X=20 $Y=20
X26 1 VIATP_C_CDNS_166 $T=520 2320 0 0 $X=20 $Y=1820
X27 1 VIATP_C_CDNS_166 $T=520 4120 0 0 $X=20 $Y=3620
X28 1 VIATP_C_CDNS_166 $T=520 5920 0 0 $X=20 $Y=5420
X29 1 VIATP_C_CDNS_166 $T=520 7720 0 0 $X=20 $Y=7220
X30 1 VIATP_C_CDNS_166 $T=2320 520 0 0 $X=1820 $Y=20
X31 1 VIATP_C_CDNS_166 $T=2320 2320 0 0 $X=1820 $Y=1820
X32 1 VIATP_C_CDNS_166 $T=2320 4120 0 0 $X=1820 $Y=3620
X33 1 VIATP_C_CDNS_166 $T=2320 5920 0 0 $X=1820 $Y=5420
X34 1 VIATP_C_CDNS_166 $T=2320 7720 0 0 $X=1820 $Y=7220
X35 1 VIATP_C_CDNS_166 $T=4120 520 0 0 $X=3620 $Y=20
X36 1 VIATP_C_CDNS_166 $T=4120 2320 0 0 $X=3620 $Y=1820
X37 1 VIATP_C_CDNS_166 $T=4120 4120 0 0 $X=3620 $Y=3620
X38 1 VIATP_C_CDNS_166 $T=4120 5920 0 0 $X=3620 $Y=5420
X39 1 VIATP_C_CDNS_166 $T=4120 7720 0 0 $X=3620 $Y=7220
X40 1 VIATP_C_CDNS_166 $T=5920 520 0 0 $X=5420 $Y=20
X41 1 VIATP_C_CDNS_166 $T=5920 2320 0 0 $X=5420 $Y=1820
X42 1 VIATP_C_CDNS_166 $T=5920 4120 0 0 $X=5420 $Y=3620
X43 1 VIATP_C_CDNS_166 $T=5920 5920 0 0 $X=5420 $Y=5420
X44 1 VIATP_C_CDNS_166 $T=5920 7720 0 0 $X=5420 $Y=7220
X45 1 VIATP_C_CDNS_166 $T=7720 520 0 0 $X=7220 $Y=20
X46 1 VIATP_C_CDNS_166 $T=7720 2320 0 0 $X=7220 $Y=1820
X47 1 VIATP_C_CDNS_166 $T=7720 4120 0 0 $X=7220 $Y=3620
X48 1 VIATP_C_CDNS_166 $T=7720 5920 0 0 $X=7220 $Y=5420
X49 1 VIATP_C_CDNS_166 $T=7720 7720 0 0 $X=7220 $Y=7220
X50 1 VIA3_C_CDNS_167 $T=1420 520 0 0 $X=1020 $Y=20
X51 1 VIA3_C_CDNS_167 $T=1420 2320 0 0 $X=1020 $Y=1820
X52 1 VIA3_C_CDNS_167 $T=1420 4120 0 0 $X=1020 $Y=3620
X53 1 VIA3_C_CDNS_167 $T=1420 5920 0 0 $X=1020 $Y=5420
X54 1 VIA3_C_CDNS_167 $T=1420 7720 0 0 $X=1020 $Y=7220
X55 1 VIA3_C_CDNS_167 $T=3220 520 0 0 $X=2820 $Y=20
X56 1 VIA3_C_CDNS_167 $T=3220 2320 0 0 $X=2820 $Y=1820
X57 1 VIA3_C_CDNS_167 $T=3220 4120 0 0 $X=2820 $Y=3620
X58 1 VIA3_C_CDNS_167 $T=3220 5920 0 0 $X=2820 $Y=5420
X59 1 VIA3_C_CDNS_167 $T=3220 7720 0 0 $X=2820 $Y=7220
X60 1 VIA3_C_CDNS_167 $T=5020 520 0 0 $X=4620 $Y=20
X61 1 VIA3_C_CDNS_167 $T=5020 2320 0 0 $X=4620 $Y=1820
X62 1 VIA3_C_CDNS_167 $T=5020 4120 0 0 $X=4620 $Y=3620
X63 1 VIA3_C_CDNS_167 $T=5020 5920 0 0 $X=4620 $Y=5420
X64 1 VIA3_C_CDNS_167 $T=5020 7720 0 0 $X=4620 $Y=7220
X65 1 VIA3_C_CDNS_167 $T=6820 520 0 0 $X=6420 $Y=20
X66 1 VIA3_C_CDNS_167 $T=6820 2320 0 0 $X=6420 $Y=1820
X67 1 VIA3_C_CDNS_167 $T=6820 4120 0 0 $X=6420 $Y=3620
X68 1 VIA3_C_CDNS_167 $T=6820 5920 0 0 $X=6420 $Y=5420
X69 1 VIA3_C_CDNS_167 $T=6820 7720 0 0 $X=6420 $Y=7220
X70 1 VIATP_C_CDNS_168 $T=1420 520 0 0 $X=1020 $Y=20
X71 1 VIATP_C_CDNS_168 $T=1420 2320 0 0 $X=1020 $Y=1820
X72 1 VIATP_C_CDNS_168 $T=1420 4120 0 0 $X=1020 $Y=3620
X73 1 VIATP_C_CDNS_168 $T=1420 5920 0 0 $X=1020 $Y=5420
X74 1 VIATP_C_CDNS_168 $T=1420 7720 0 0 $X=1020 $Y=7220
X75 1 VIATP_C_CDNS_168 $T=3220 520 0 0 $X=2820 $Y=20
X76 1 VIATP_C_CDNS_168 $T=3220 2320 0 0 $X=2820 $Y=1820
X77 1 VIATP_C_CDNS_168 $T=3220 4120 0 0 $X=2820 $Y=3620
X78 1 VIATP_C_CDNS_168 $T=3220 5920 0 0 $X=2820 $Y=5420
X79 1 VIATP_C_CDNS_168 $T=3220 7720 0 0 $X=2820 $Y=7220
X80 1 VIATP_C_CDNS_168 $T=5020 520 0 0 $X=4620 $Y=20
X81 1 VIATP_C_CDNS_168 $T=5020 2320 0 0 $X=4620 $Y=1820
X82 1 VIATP_C_CDNS_168 $T=5020 4120 0 0 $X=4620 $Y=3620
X83 1 VIATP_C_CDNS_168 $T=5020 5920 0 0 $X=4620 $Y=5420
X84 1 VIATP_C_CDNS_168 $T=5020 7720 0 0 $X=4620 $Y=7220
X85 1 VIATP_C_CDNS_168 $T=6820 520 0 0 $X=6420 $Y=20
X86 1 VIATP_C_CDNS_168 $T=6820 2320 0 0 $X=6420 $Y=1820
X87 1 VIATP_C_CDNS_168 $T=6820 4120 0 0 $X=6420 $Y=3620
X88 1 VIATP_C_CDNS_168 $T=6820 5920 0 0 $X=6420 $Y=5420
X89 1 VIATP_C_CDNS_168 $T=6820 7720 0 0 $X=6420 $Y=7220
X90 1 VIA3_C_CDNS_169 $T=520 1420 0 0 $X=20 $Y=1020
X91 1 VIA3_C_CDNS_169 $T=520 3220 0 0 $X=20 $Y=2820
X92 1 VIA3_C_CDNS_169 $T=520 5020 0 0 $X=20 $Y=4620
X93 1 VIA3_C_CDNS_169 $T=520 6820 0 0 $X=20 $Y=6420
X94 1 VIA3_C_CDNS_169 $T=2320 1420 0 0 $X=1820 $Y=1020
X95 1 VIA3_C_CDNS_169 $T=2320 3220 0 0 $X=1820 $Y=2820
X96 1 VIA3_C_CDNS_169 $T=2320 5020 0 0 $X=1820 $Y=4620
X97 1 VIA3_C_CDNS_169 $T=2320 6820 0 0 $X=1820 $Y=6420
X98 1 VIA3_C_CDNS_169 $T=4120 1420 0 0 $X=3620 $Y=1020
X99 1 VIA3_C_CDNS_169 $T=4120 3220 0 0 $X=3620 $Y=2820
X100 1 VIA3_C_CDNS_169 $T=4120 5020 0 0 $X=3620 $Y=4620
X101 1 VIA3_C_CDNS_169 $T=4120 6820 0 0 $X=3620 $Y=6420
X102 1 VIA3_C_CDNS_169 $T=5920 1420 0 0 $X=5420 $Y=1020
X103 1 VIA3_C_CDNS_169 $T=5920 3220 0 0 $X=5420 $Y=2820
X104 1 VIA3_C_CDNS_169 $T=5920 5020 0 0 $X=5420 $Y=4620
X105 1 VIA3_C_CDNS_169 $T=5920 6820 0 0 $X=5420 $Y=6420
X106 1 VIA3_C_CDNS_169 $T=7720 1420 0 0 $X=7220 $Y=1020
X107 1 VIA3_C_CDNS_169 $T=7720 3220 0 0 $X=7220 $Y=2820
X108 1 VIA3_C_CDNS_169 $T=7720 5020 0 0 $X=7220 $Y=4620
X109 1 VIA3_C_CDNS_169 $T=7720 6820 0 0 $X=7220 $Y=6420
X110 1 VIATP_C_CDNS_170 $T=520 1420 0 0 $X=20 $Y=1020
X111 1 VIATP_C_CDNS_170 $T=520 3220 0 0 $X=20 $Y=2820
X112 1 VIATP_C_CDNS_170 $T=520 5020 0 0 $X=20 $Y=4620
X113 1 VIATP_C_CDNS_170 $T=520 6820 0 0 $X=20 $Y=6420
X114 1 VIATP_C_CDNS_170 $T=2320 1420 0 0 $X=1820 $Y=1020
X115 1 VIATP_C_CDNS_170 $T=2320 3220 0 0 $X=1820 $Y=2820
X116 1 VIATP_C_CDNS_170 $T=2320 5020 0 0 $X=1820 $Y=4620
X117 1 VIATP_C_CDNS_170 $T=2320 6820 0 0 $X=1820 $Y=6420
X118 1 VIATP_C_CDNS_170 $T=4120 1420 0 0 $X=3620 $Y=1020
X119 1 VIATP_C_CDNS_170 $T=4120 3220 0 0 $X=3620 $Y=2820
X120 1 VIATP_C_CDNS_170 $T=4120 5020 0 0 $X=3620 $Y=4620
X121 1 VIATP_C_CDNS_170 $T=4120 6820 0 0 $X=3620 $Y=6420
X122 1 VIATP_C_CDNS_170 $T=5920 1420 0 0 $X=5420 $Y=1020
X123 1 VIATP_C_CDNS_170 $T=5920 3220 0 0 $X=5420 $Y=2820
X124 1 VIATP_C_CDNS_170 $T=5920 5020 0 0 $X=5420 $Y=4620
X125 1 VIATP_C_CDNS_170 $T=5920 6820 0 0 $X=5420 $Y=6420
X126 1 VIATP_C_CDNS_170 $T=7720 1420 0 0 $X=7220 $Y=1020
X127 1 VIATP_C_CDNS_170 $T=7720 3220 0 0 $X=7220 $Y=2820
X128 1 VIATP_C_CDNS_170 $T=7720 5020 0 0 $X=7220 $Y=4620
X129 1 VIATP_C_CDNS_170 $T=7720 6820 0 0 $X=7220 $Y=6420
.ends M3_MTP_8_cell

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: M3_MTP_CornerCell                               *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt M3_MTP_CornerCell 1 2
** N=2 EP=2 FDC=0
.ends M3_MTP_CornerCell

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: MASCO__B4                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt MASCO__B4 1 2
** N=2 EP=2 FDC=0
X0 1 2 M3_MTPcell $T=0 0 0 0 $X=0 $Y=0
X1 1 2 M3_MTPcell $T=0 7560 0 0 $X=0 $Y=7560
X2 1 2 M3_MTPcell $T=7560 0 0 0 $X=7560 $Y=0
X3 1 2 M3_MTPcell $T=7560 7560 0 0 $X=7560 $Y=7560
.ends MASCO__B4

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: MASCO__B8                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt MASCO__B8 1 2
** N=2 EP=2 FDC=0
X0 1 2 MASCO__B4 $T=0 0 0 0 $X=0 $Y=0
X1 1 2 MASCO__B4 $T=0 15120 0 0 $X=0 $Y=15120
X2 1 2 MASCO__B4 $T=15120 0 0 0 $X=15120 $Y=0
X3 1 2 MASCO__B4 $T=15120 15120 0 0 $X=15120 $Y=15120
.ends MASCO__B8

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: MASCO__B30                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt MASCO__B30 1 2
** N=2 EP=2 FDC=0
X0 1 2 M3_MTP_8_cell $T=0 0 0 0 $X=0 $Y=0
X1 1 2 M3_MTP_8_cell $T=0 8240 0 0 $X=0 $Y=8240
X2 1 2 M3_MTP_8_cell $T=8240 0 0 0 $X=8240 $Y=0
X3 1 2 M3_MTP_8_cell $T=8240 8240 0 0 $X=8240 $Y=8240
.ends MASCO__B30

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_149                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_149 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_149

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_150                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_150 1
** N=1 EP=1 FDC=0
.ends VIA3_C_CDNS_150

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_151                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_151 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_151

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIATP_C_CDNS_152                                *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIATP_C_CDNS_152 1
** N=1 EP=1 FDC=0
.ends VIATP_C_CDNS_152

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: MASCO__B33                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt MASCO__B33 1
** N=1 EP=1 FDC=0
X0 1 VIA2_C_CDNS_149 $T=1090 12110 0 0 $X=0 $Y=0
X1 1 VIA3_C_CDNS_150 $T=1090 12110 0 0 $X=0 $Y=0
X2 1 VIA1_C_CDNS_151 $T=1090 12110 0 0 $X=0 $Y=0
X3 1 VIATP_C_CDNS_152 $T=1090 12110 0 0 $X=0 $Y=0
.ends MASCO__B33

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIATP_C_CDNS_159                                *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIATP_C_CDNS_159 1 2
** N=2 EP=2 FDC=0
.ends VIATP_C_CDNS_159

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: MASCO__B34                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt MASCO__B34 1 2
** N=2 EP=2 FDC=0
X0 1 2 VIA3_C_CDNS_81 $T=1090 27700 0 0 $X=0 $Y=0
X1 1 2 VIA2_C_CDNS_82 $T=1090 27700 0 0 $X=0 $Y=0
X2 1 2 VIATP_C_CDNS_159 $T=1090 27700 0 0 $X=0 $Y=0
.ends MASCO__B34

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: MASCO__B35                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt MASCO__B35 1 2
** N=2 EP=2 FDC=0
X0 1 2 VIA3_C_CDNS_81 $T=1090 27700 1 0 $X=0 $Y=0
X1 1 2 VIA2_C_CDNS_82 $T=1090 27700 1 0 $X=0 $Y=0
X2 1 2 VIATP_C_CDNS_159 $T=1090 27700 1 0 $X=0 $Y=0
.ends MASCO__B35

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: MASCO__B39                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt MASCO__B39 1 2
** N=2 EP=2 FDC=0
X0 1 2 MASCO__B30 $T=0 0 0 0 $X=0 $Y=0
X1 1 2 MASCO__B30 $T=0 16480 0 0 $X=0 $Y=16480
X2 1 2 MASCO__B30 $T=16480 0 0 0 $X=16480 $Y=0
X3 1 2 MASCO__B30 $T=16480 16480 0 0 $X=16480 $Y=16480
.ends MASCO__B39

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: CurrretMirrorx10_HV                             *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt CurrretMirrorx10_HV 1 2 3 4
** N=6 EP=4 FDC=22
X0 3 VIA2_C_CDNS_97 $T=90525 241920 0 0 $X=90035 $Y=241430
X1 3 VIA2_C_CDNS_97 $T=113005 241920 0 0 $X=112515 $Y=241430
X2 3 VIA2_C_CDNS_97 $T=155135 241920 0 0 $X=154645 $Y=241430
X3 3 VIA2_C_CDNS_97 $T=177615 241920 0 0 $X=177125 $Y=241430
X4 3 VIA2_C_CDNS_97 $T=252050 241920 0 0 $X=251560 $Y=241430
X5 3 VIA2_C_CDNS_97 $T=274530 241920 0 0 $X=274040 $Y=241430
X6 3 VIA2_C_CDNS_97 $T=316660 241920 0 0 $X=316170 $Y=241430
X7 3 VIA2_C_CDNS_97 $T=339140 241920 0 0 $X=338650 $Y=241430
X8 3 VIA2_C_CDNS_97 $T=381270 241920 0 0 $X=380780 $Y=241430
X9 3 VIA2_C_CDNS_97 $T=403750 241920 0 0 $X=403260 $Y=241430
X10 1 5 1 3 nedia_bjt_CDNS_125 $T=69460 81200 0 0 $X=53240 $Y=61810
X11 1 4 5 2 nedia_bjt_CDNS_125 $T=69460 184700 0 0 $X=53240 $Y=165310
X12 1 4 5 2 nedia_bjt_CDNS_125 $T=101760 81200 0 0 $X=85540 $Y=61810
X13 1 5 1 3 nedia_bjt_CDNS_125 $T=101760 184700 0 0 $X=85540 $Y=165310
X14 1 5 1 3 nedia_bjt_CDNS_125 $T=134060 81200 0 0 $X=117840 $Y=61810
X15 1 4 5 2 nedia_bjt_CDNS_125 $T=134060 184700 0 0 $X=117840 $Y=165310
X16 1 4 5 2 nedia_bjt_CDNS_125 $T=166360 81200 0 0 $X=150140 $Y=61810
X17 1 5 1 3 nedia_bjt_CDNS_125 $T=166360 184700 0 0 $X=150140 $Y=165310
X18 1 5 1 3 nedia_bjt_CDNS_125 $T=198660 81200 0 0 $X=182440 $Y=61810
X19 1 4 5 2 nedia_bjt_CDNS_125 $T=198660 184700 0 0 $X=182440 $Y=165310
X20 1 3 6 2 nedia_bjt_CDNS_125 $T=230960 81200 0 0 $X=214740 $Y=61810
X21 1 6 1 3 nedia_bjt_CDNS_125 $T=230960 184700 0 0 $X=214740 $Y=165310
X22 1 4 5 2 nedia_bjt_CDNS_125 $T=263260 81200 0 0 $X=247040 $Y=61810
X23 1 5 1 3 nedia_bjt_CDNS_125 $T=263260 184700 0 0 $X=247040 $Y=165310
X24 1 5 1 3 nedia_bjt_CDNS_125 $T=295560 81200 0 0 $X=279340 $Y=61810
X25 1 4 5 2 nedia_bjt_CDNS_125 $T=295560 184700 0 0 $X=279340 $Y=165310
X26 1 4 5 2 nedia_bjt_CDNS_125 $T=327860 81200 0 0 $X=311640 $Y=61810
X27 1 5 1 3 nedia_bjt_CDNS_125 $T=327860 184700 0 0 $X=311640 $Y=165310
X28 1 5 1 3 nedia_bjt_CDNS_125 $T=360160 81200 0 0 $X=343940 $Y=61810
X29 1 4 5 2 nedia_bjt_CDNS_125 $T=360160 184700 0 0 $X=343940 $Y=165310
X30 1 4 5 2 nedia_bjt_CDNS_125 $T=392460 81200 0 0 $X=376240 $Y=61810
X31 1 5 1 3 nedia_bjt_CDNS_125 $T=392460 184700 0 0 $X=376240 $Y=165310
X32 4 1 VIA2_C_CDNS_153 $T=60470 204700 0 0 $X=56470 $Y=177000
X33 4 1 VIA2_C_CDNS_153 $T=78450 204700 0 0 $X=74450 $Y=177000
X34 4 1 VIA2_C_CDNS_153 $T=92770 101200 1 0 $X=88770 $Y=73500
X35 4 1 VIA2_C_CDNS_153 $T=110750 101200 1 0 $X=106750 $Y=73500
X36 4 1 VIA2_C_CDNS_153 $T=125070 204700 0 0 $X=121070 $Y=177000
X37 4 1 VIA2_C_CDNS_153 $T=143050 204700 0 0 $X=139050 $Y=177000
X38 4 1 VIA2_C_CDNS_153 $T=157370 101200 1 0 $X=153370 $Y=73500
X39 4 1 VIA2_C_CDNS_153 $T=175350 101200 1 0 $X=171350 $Y=73500
X40 4 1 VIA2_C_CDNS_153 $T=189670 204700 0 0 $X=185670 $Y=177000
X41 4 1 VIA2_C_CDNS_153 $T=207650 204700 0 0 $X=203650 $Y=177000
X42 4 1 VIA2_C_CDNS_153 $T=254270 101200 1 0 $X=250270 $Y=73500
X43 4 1 VIA2_C_CDNS_153 $T=272250 101200 1 0 $X=268250 $Y=73500
X44 4 1 VIA2_C_CDNS_153 $T=286570 204700 0 0 $X=282570 $Y=177000
X45 4 1 VIA2_C_CDNS_153 $T=304550 204700 0 0 $X=300550 $Y=177000
X46 4 1 VIA2_C_CDNS_153 $T=318870 101200 1 0 $X=314870 $Y=73500
X47 4 1 VIA2_C_CDNS_153 $T=336850 101200 1 0 $X=332850 $Y=73500
X48 4 1 VIA2_C_CDNS_153 $T=351170 204700 0 0 $X=347170 $Y=177000
X49 4 1 VIA2_C_CDNS_153 $T=369150 204700 0 0 $X=365150 $Y=177000
X50 4 1 VIA2_C_CDNS_153 $T=383470 101200 1 0 $X=379470 $Y=73500
X51 4 1 VIA2_C_CDNS_153 $T=401450 101200 1 0 $X=397450 $Y=73500
X52 4 1 VIATP_C_CDNS_154 $T=60470 204700 0 0 $X=56470 $Y=177000
X53 4 1 VIATP_C_CDNS_154 $T=78450 204700 0 0 $X=74450 $Y=177000
X54 4 1 VIATP_C_CDNS_154 $T=92770 101200 1 0 $X=88770 $Y=73500
X55 4 1 VIATP_C_CDNS_154 $T=110750 101200 1 0 $X=106750 $Y=73500
X56 4 1 VIATP_C_CDNS_154 $T=125070 204700 0 0 $X=121070 $Y=177000
X57 4 1 VIATP_C_CDNS_154 $T=143050 204700 0 0 $X=139050 $Y=177000
X58 4 1 VIATP_C_CDNS_154 $T=157370 101200 1 0 $X=153370 $Y=73500
X59 4 1 VIATP_C_CDNS_154 $T=175350 101200 1 0 $X=171350 $Y=73500
X60 4 1 VIATP_C_CDNS_154 $T=189670 204700 0 0 $X=185670 $Y=177000
X61 4 1 VIATP_C_CDNS_154 $T=207650 204700 0 0 $X=203650 $Y=177000
X62 4 1 VIATP_C_CDNS_154 $T=254270 101200 1 0 $X=250270 $Y=73500
X63 4 1 VIATP_C_CDNS_154 $T=272250 101200 1 0 $X=268250 $Y=73500
X64 4 1 VIATP_C_CDNS_154 $T=286570 204700 0 0 $X=282570 $Y=177000
X65 4 1 VIATP_C_CDNS_154 $T=304550 204700 0 0 $X=300550 $Y=177000
X66 4 1 VIATP_C_CDNS_154 $T=318870 101200 1 0 $X=314870 $Y=73500
X67 4 1 VIATP_C_CDNS_154 $T=336850 101200 1 0 $X=332850 $Y=73500
X68 4 1 VIATP_C_CDNS_154 $T=351170 204700 0 0 $X=347170 $Y=177000
X69 4 1 VIATP_C_CDNS_154 $T=369150 204700 0 0 $X=365150 $Y=177000
X70 4 1 VIATP_C_CDNS_154 $T=383470 101200 1 0 $X=379470 $Y=73500
X71 4 1 VIATP_C_CDNS_154 $T=401450 101200 1 0 $X=397450 $Y=73500
X72 4 1 VIA3_C_CDNS_155 $T=60470 204700 0 0 $X=56470 $Y=177000
X73 4 1 VIA3_C_CDNS_155 $T=78450 204700 0 0 $X=74450 $Y=177000
X74 4 1 VIA3_C_CDNS_155 $T=92770 101200 1 0 $X=88770 $Y=73500
X75 4 1 VIA3_C_CDNS_155 $T=110750 101200 1 0 $X=106750 $Y=73500
X76 4 1 VIA3_C_CDNS_155 $T=125070 204700 0 0 $X=121070 $Y=177000
X77 4 1 VIA3_C_CDNS_155 $T=143050 204700 0 0 $X=139050 $Y=177000
X78 4 1 VIA3_C_CDNS_155 $T=157370 101200 1 0 $X=153370 $Y=73500
X79 4 1 VIA3_C_CDNS_155 $T=175350 101200 1 0 $X=171350 $Y=73500
X80 4 1 VIA3_C_CDNS_155 $T=189670 204700 0 0 $X=185670 $Y=177000
X81 4 1 VIA3_C_CDNS_155 $T=207650 204700 0 0 $X=203650 $Y=177000
X82 4 1 VIA3_C_CDNS_155 $T=254270 101200 1 0 $X=250270 $Y=73500
X83 4 1 VIA3_C_CDNS_155 $T=272250 101200 1 0 $X=268250 $Y=73500
X84 4 1 VIA3_C_CDNS_155 $T=286570 204700 0 0 $X=282570 $Y=177000
X85 4 1 VIA3_C_CDNS_155 $T=304550 204700 0 0 $X=300550 $Y=177000
X86 4 1 VIA3_C_CDNS_155 $T=318870 101200 1 0 $X=314870 $Y=73500
X87 4 1 VIA3_C_CDNS_155 $T=336850 101200 1 0 $X=332850 $Y=73500
X88 4 1 VIA3_C_CDNS_155 $T=351170 204700 0 0 $X=347170 $Y=177000
X89 4 1 VIA3_C_CDNS_155 $T=369150 204700 0 0 $X=365150 $Y=177000
X90 4 1 VIA3_C_CDNS_155 $T=383470 101200 1 0 $X=379470 $Y=73500
X91 4 1 VIA3_C_CDNS_155 $T=401450 101200 1 0 $X=397450 $Y=73500
X92 5 1 VIA2_C_CDNS_156 $T=62970 101200 1 0 $X=61470 $Y=73500
X93 5 1 VIA2_C_CDNS_156 $T=75950 101200 1 0 $X=74450 $Y=73500
X94 5 1 VIA2_C_CDNS_156 $T=95270 204700 0 0 $X=93770 $Y=177000
X95 5 1 VIA2_C_CDNS_156 $T=108250 204700 0 0 $X=106750 $Y=177000
X96 5 1 VIA2_C_CDNS_156 $T=127570 101200 1 0 $X=126070 $Y=73500
X97 5 1 VIA2_C_CDNS_156 $T=140550 101200 1 0 $X=139050 $Y=73500
X98 5 1 VIA2_C_CDNS_156 $T=159870 204700 0 0 $X=158370 $Y=177000
X99 5 1 VIA2_C_CDNS_156 $T=172850 204700 0 0 $X=171350 $Y=177000
X100 5 1 VIA2_C_CDNS_156 $T=192170 101200 1 0 $X=190670 $Y=73500
X101 5 1 VIA2_C_CDNS_156 $T=205150 101200 1 0 $X=203650 $Y=73500
X102 5 1 VIA2_C_CDNS_156 $T=256770 204700 0 0 $X=255270 $Y=177000
X103 5 1 VIA2_C_CDNS_156 $T=269750 204700 0 0 $X=268250 $Y=177000
X104 5 1 VIA2_C_CDNS_156 $T=289070 101200 1 0 $X=287570 $Y=73500
X105 5 1 VIA2_C_CDNS_156 $T=302050 101200 1 0 $X=300550 $Y=73500
X106 5 1 VIA2_C_CDNS_156 $T=321370 204700 0 0 $X=319870 $Y=177000
X107 5 1 VIA2_C_CDNS_156 $T=334350 204700 0 0 $X=332850 $Y=177000
X108 5 1 VIA2_C_CDNS_156 $T=353670 101200 1 0 $X=352170 $Y=73500
X109 5 1 VIA2_C_CDNS_156 $T=366650 101200 1 0 $X=365150 $Y=73500
X110 5 1 VIA2_C_CDNS_156 $T=385970 204700 0 0 $X=384470 $Y=177000
X111 5 1 VIA2_C_CDNS_156 $T=398950 204700 0 0 $X=397450 $Y=177000
X112 5 1 VIA3_C_CDNS_157 $T=62970 101200 1 0 $X=61470 $Y=73500
X113 5 1 VIA3_C_CDNS_157 $T=75950 101200 1 0 $X=74450 $Y=73500
X114 5 1 VIA3_C_CDNS_157 $T=95270 204700 0 0 $X=93770 $Y=177000
X115 5 1 VIA3_C_CDNS_157 $T=108250 204700 0 0 $X=106750 $Y=177000
X116 5 1 VIA3_C_CDNS_157 $T=127570 101200 1 0 $X=126070 $Y=73500
X117 5 1 VIA3_C_CDNS_157 $T=140550 101200 1 0 $X=139050 $Y=73500
X118 5 1 VIA3_C_CDNS_157 $T=159870 204700 0 0 $X=158370 $Y=177000
X119 5 1 VIA3_C_CDNS_157 $T=172850 204700 0 0 $X=171350 $Y=177000
X120 5 1 VIA3_C_CDNS_157 $T=192170 101200 1 0 $X=190670 $Y=73500
X121 5 1 VIA3_C_CDNS_157 $T=205150 101200 1 0 $X=203650 $Y=73500
X122 5 1 VIA3_C_CDNS_157 $T=256770 204700 0 0 $X=255270 $Y=177000
X123 5 1 VIA3_C_CDNS_157 $T=269750 204700 0 0 $X=268250 $Y=177000
X124 5 1 VIA3_C_CDNS_157 $T=289070 101200 1 0 $X=287570 $Y=73500
X125 5 1 VIA3_C_CDNS_157 $T=302050 101200 1 0 $X=300550 $Y=73500
X126 5 1 VIA3_C_CDNS_157 $T=321370 204700 0 0 $X=319870 $Y=177000
X127 5 1 VIA3_C_CDNS_157 $T=334350 204700 0 0 $X=332850 $Y=177000
X128 5 1 VIA3_C_CDNS_157 $T=353670 101200 1 0 $X=352170 $Y=73500
X129 5 1 VIA3_C_CDNS_157 $T=366650 101200 1 0 $X=365150 $Y=73500
X130 5 1 VIA3_C_CDNS_157 $T=385970 204700 0 0 $X=384470 $Y=177000
X131 5 1 VIA3_C_CDNS_157 $T=398950 204700 0 0 $X=397450 $Y=177000
X132 5 1 VIATP_C_CDNS_158 $T=62970 101200 1 0 $X=61470 $Y=73500
X133 5 1 VIATP_C_CDNS_158 $T=75950 101200 1 0 $X=74450 $Y=73500
X134 5 1 VIATP_C_CDNS_158 $T=95270 204700 0 0 $X=93770 $Y=177000
X135 5 1 VIATP_C_CDNS_158 $T=108250 204700 0 0 $X=106750 $Y=177000
X136 5 1 VIATP_C_CDNS_158 $T=127570 101200 1 0 $X=126070 $Y=73500
X137 5 1 VIATP_C_CDNS_158 $T=140550 101200 1 0 $X=139050 $Y=73500
X138 5 1 VIATP_C_CDNS_158 $T=159870 204700 0 0 $X=158370 $Y=177000
X139 5 1 VIATP_C_CDNS_158 $T=172850 204700 0 0 $X=171350 $Y=177000
X140 5 1 VIATP_C_CDNS_158 $T=192170 101200 1 0 $X=190670 $Y=73500
X141 5 1 VIATP_C_CDNS_158 $T=205150 101200 1 0 $X=203650 $Y=73500
X142 5 1 VIATP_C_CDNS_158 $T=256770 204700 0 0 $X=255270 $Y=177000
X143 5 1 VIATP_C_CDNS_158 $T=269750 204700 0 0 $X=268250 $Y=177000
X144 5 1 VIATP_C_CDNS_158 $T=289070 101200 1 0 $X=287570 $Y=73500
X145 5 1 VIATP_C_CDNS_158 $T=302050 101200 1 0 $X=300550 $Y=73500
X146 5 1 VIATP_C_CDNS_158 $T=321370 204700 0 0 $X=319870 $Y=177000
X147 5 1 VIATP_C_CDNS_158 $T=334350 204700 0 0 $X=332850 $Y=177000
X148 5 1 VIATP_C_CDNS_158 $T=353670 101200 1 0 $X=352170 $Y=73500
X149 5 1 VIATP_C_CDNS_158 $T=366650 101200 1 0 $X=365150 $Y=73500
X150 5 1 VIATP_C_CDNS_158 $T=385970 204700 0 0 $X=384470 $Y=177000
X151 5 1 VIATP_C_CDNS_158 $T=398950 204700 0 0 $X=397450 $Y=177000
X152 3 1 VIA2_C_CDNS_160 $T=90525 204695 0 0 $X=90025 $Y=178380
X153 3 1 VIA2_C_CDNS_160 $T=113005 204695 0 0 $X=112505 $Y=178380
X154 3 1 VIA2_C_CDNS_160 $T=155135 204695 0 0 $X=154635 $Y=178380
X155 3 1 VIA2_C_CDNS_160 $T=177615 204695 0 0 $X=177115 $Y=178380
X156 3 1 VIA2_C_CDNS_160 $T=252050 204695 0 0 $X=251550 $Y=178380
X157 3 1 VIA2_C_CDNS_160 $T=274530 204695 0 0 $X=274030 $Y=178380
X158 3 1 VIA2_C_CDNS_160 $T=316660 204695 0 0 $X=316160 $Y=178380
X159 3 1 VIA2_C_CDNS_160 $T=339140 204695 0 0 $X=338640 $Y=178380
X160 3 1 VIA2_C_CDNS_160 $T=381270 204695 0 0 $X=380770 $Y=178380
X161 3 1 VIA2_C_CDNS_160 $T=403750 204695 0 0 $X=403250 $Y=178380
X162 3 1 VIA1_C_CDNS_161 $T=90525 204695 0 0 $X=90025 $Y=178380
X163 3 1 VIA1_C_CDNS_161 $T=113005 204695 0 0 $X=112505 $Y=178380
X164 3 1 VIA1_C_CDNS_161 $T=155135 204695 0 0 $X=154635 $Y=178380
X165 3 1 VIA1_C_CDNS_161 $T=177615 204695 0 0 $X=177115 $Y=178380
X166 3 1 VIA1_C_CDNS_161 $T=252050 204695 0 0 $X=251550 $Y=178380
X167 3 1 VIA1_C_CDNS_161 $T=274530 204695 0 0 $X=274030 $Y=178380
X168 3 1 VIA1_C_CDNS_161 $T=316660 204695 0 0 $X=316160 $Y=178380
X169 3 1 VIA1_C_CDNS_161 $T=339140 204695 0 0 $X=338640 $Y=178380
X170 3 1 VIA1_C_CDNS_161 $T=381270 204695 0 0 $X=380770 $Y=178380
X171 3 1 VIA1_C_CDNS_161 $T=403750 204695 0 0 $X=403250 $Y=178380
X172 3 VIA1_C_CDNS_162 $T=69460 66790 0 0 $X=69110 $Y=66290
X173 3 VIA1_C_CDNS_162 $T=69460 135610 0 0 $X=69110 $Y=135110
X174 2 VIA1_C_CDNS_162 $T=69460 170290 0 0 $X=69110 $Y=169790
X175 2 VIA1_C_CDNS_162 $T=69460 239110 0 0 $X=69110 $Y=238610
X176 2 VIA1_C_CDNS_162 $T=101760 66790 0 0 $X=101410 $Y=66290
X177 2 VIA1_C_CDNS_162 $T=101760 135610 0 0 $X=101410 $Y=135110
X178 3 VIA1_C_CDNS_162 $T=101760 170290 0 0 $X=101410 $Y=169790
X179 3 VIA1_C_CDNS_162 $T=101760 239110 0 0 $X=101410 $Y=238610
X180 3 VIA1_C_CDNS_162 $T=134060 66790 0 0 $X=133710 $Y=66290
X181 3 VIA1_C_CDNS_162 $T=134060 135610 0 0 $X=133710 $Y=135110
X182 2 VIA1_C_CDNS_162 $T=134060 170290 0 0 $X=133710 $Y=169790
X183 2 VIA1_C_CDNS_162 $T=134060 239110 0 0 $X=133710 $Y=238610
X184 2 VIA1_C_CDNS_162 $T=166360 66790 0 0 $X=166010 $Y=66290
X185 2 VIA1_C_CDNS_162 $T=166360 135610 0 0 $X=166010 $Y=135110
X186 3 VIA1_C_CDNS_162 $T=166360 170290 0 0 $X=166010 $Y=169790
X187 3 VIA1_C_CDNS_162 $T=166360 239110 0 0 $X=166010 $Y=238610
X188 3 VIA1_C_CDNS_162 $T=198660 66790 0 0 $X=198310 $Y=66290
X189 3 VIA1_C_CDNS_162 $T=198660 135610 0 0 $X=198310 $Y=135110
X190 2 VIA1_C_CDNS_162 $T=198660 170290 0 0 $X=198310 $Y=169790
X191 2 VIA1_C_CDNS_162 $T=198660 239110 0 0 $X=198310 $Y=238610
X192 2 VIA1_C_CDNS_162 $T=230960 66790 0 0 $X=230610 $Y=66290
X193 2 VIA1_C_CDNS_162 $T=230960 135610 0 0 $X=230610 $Y=135110
X194 3 VIA1_C_CDNS_162 $T=230960 170290 0 0 $X=230610 $Y=169790
X195 3 VIA1_C_CDNS_162 $T=230960 239110 0 0 $X=230610 $Y=238610
X196 2 VIA1_C_CDNS_162 $T=263260 66790 0 0 $X=262910 $Y=66290
X197 2 VIA1_C_CDNS_162 $T=263260 135610 0 0 $X=262910 $Y=135110
X198 3 VIA1_C_CDNS_162 $T=263260 170290 0 0 $X=262910 $Y=169790
X199 3 VIA1_C_CDNS_162 $T=263260 239110 0 0 $X=262910 $Y=238610
X200 3 VIA1_C_CDNS_162 $T=295560 66790 0 0 $X=295210 $Y=66290
X201 3 VIA1_C_CDNS_162 $T=295560 135610 0 0 $X=295210 $Y=135110
X202 2 VIA1_C_CDNS_162 $T=295560 170290 0 0 $X=295210 $Y=169790
X203 2 VIA1_C_CDNS_162 $T=295560 239110 0 0 $X=295210 $Y=238610
X204 2 VIA1_C_CDNS_162 $T=327860 66790 0 0 $X=327510 $Y=66290
X205 3 VIA1_C_CDNS_162 $T=327860 170290 0 0 $X=327510 $Y=169790
X206 3 VIA1_C_CDNS_162 $T=327860 239110 0 0 $X=327510 $Y=238610
X207 3 VIA1_C_CDNS_162 $T=360160 66790 0 0 $X=359810 $Y=66290
X208 3 VIA1_C_CDNS_162 $T=360160 135610 0 0 $X=359810 $Y=135110
X209 2 VIA1_C_CDNS_162 $T=360160 170290 0 0 $X=359810 $Y=169790
X210 2 VIA1_C_CDNS_162 $T=360160 239110 0 0 $X=359810 $Y=238610
X211 2 VIA1_C_CDNS_162 $T=392460 66790 0 0 $X=392110 $Y=66290
X212 2 VIA1_C_CDNS_162 $T=392460 135610 0 0 $X=392110 $Y=135110
X213 3 VIA1_C_CDNS_162 $T=392460 170290 0 0 $X=392110 $Y=169790
X214 3 VIA1_C_CDNS_162 $T=392460 239110 0 0 $X=392110 $Y=238610
X215 6 1 VIA1_C_CDNS_164 $T=229170 145390 0 0 $X=228420 $Y=142560
X216 6 1 VIA1_C_CDNS_164 $T=232750 145390 0 0 $X=232000 $Y=142560
X217 4 1 M3_MTP_8_cell $T=0 249175 0 0 $X=0 $Y=249175
X218 4 1 M3_MTP_8_cell $T=8240 249175 0 0 $X=8240 $Y=249175
X219 4 1 M3_MTP_8_cell $T=16480 249175 0 0 $X=16480 $Y=249175
X220 4 1 M3_MTP_8_cell $T=24720 249175 0 0 $X=24720 $Y=249175
X221 4 1 M3_MTP_8_cell $T=399880 5 0 0 $X=399880 $Y=5
X222 4 1 M3_MTP_8_cell $T=399880 8245 0 0 $X=399880 $Y=8245
X223 4 1 M3_MTP_8_cell $T=399880 16485 0 0 $X=399880 $Y=16485
X224 4 1 M3_MTP_8_cell $T=399880 24725 0 0 $X=399880 $Y=24725
X225 4 1 M3_MTP_8_cell $T=399880 272950 0 0 $X=399880 $Y=272950
X226 4 1 M3_MTP_8_cell $T=399880 281190 0 0 $X=399880 $Y=281190
X227 4 1 M3_MTP_8_cell $T=399880 289430 0 0 $X=399880 $Y=289430
X228 4 1 M3_MTP_8_cell $T=399880 297670 0 0 $X=399880 $Y=297670
X229 4 1 M3_MTP_8_cell $T=428960 249175 0 0 $X=428960 $Y=249175
X230 4 1 M3_MTP_8_cell $T=437200 249175 0 0 $X=437200 $Y=249175
X231 4 1 M3_MTP_8_cell $T=445440 249175 0 0 $X=445440 $Y=249175
X232 4 1 M3_MTP_8_cell $T=453680 249175 0 0 $X=453680 $Y=249175
X233 4 1 M3_MTP_CornerCell $T=0 49445 1 0 $X=0 $Y=5
X234 4 1 M3_MTP_CornerCell $T=0 256470 0 0 $X=0 $Y=256470
X235 4 1 M3_MTP_CornerCell $T=461920 49445 0 180 $X=412480 $Y=5
X236 4 1 M3_MTP_CornerCell $T=461920 256470 1 180 $X=412480 $Y=256470
X237 5 1 MASCO__B4 $T=390360 137830 0 0 $X=390360 $Y=137830
X238 5 1 MASCO__B4 $T=390360 152950 0 0 $X=390360 $Y=152950
X239 5 1 MASCO__B8 $T=57720 137830 0 0 $X=57720 $Y=137830
X240 5 1 MASCO__B8 $T=87960 137830 0 0 $X=87960 $Y=137830
X241 5 1 MASCO__B8 $T=118200 137830 0 0 $X=118200 $Y=137830
X242 5 1 MASCO__B8 $T=148440 137830 0 0 $X=148440 $Y=137830
X243 5 1 MASCO__B8 $T=178680 137830 0 0 $X=178680 $Y=137830
X244 5 1 MASCO__B8 $T=208920 137830 0 0 $X=208920 $Y=137830
X245 5 1 MASCO__B8 $T=239160 137830 0 0 $X=239160 $Y=137830
X246 5 1 MASCO__B8 $T=269400 137830 0 0 $X=269400 $Y=137830
X247 5 1 MASCO__B8 $T=299640 137830 0 0 $X=299640 $Y=137830
X248 5 1 MASCO__B8 $T=329880 137830 0 0 $X=329880 $Y=137830
X249 5 1 MASCO__B8 $T=360120 137830 0 0 $X=360120 $Y=137830
X250 4 1 MASCO__B30 $T=383400 5 0 0 $X=383400 $Y=5
X251 4 1 MASCO__B30 $T=383400 16485 0 0 $X=383400 $Y=16485
X252 4 1 MASCO__B30 $T=383400 272950 0 0 $X=383400 $Y=272950
X253 4 1 MASCO__B30 $T=383400 289430 0 0 $X=383400 $Y=289430
X254 1 MASCO__B33 $T=66580 38950 0 0 $X=66580 $Y=38950
X255 1 MASCO__B33 $T=70160 38950 0 0 $X=70160 $Y=38950
X256 1 MASCO__B33 $T=98880 242730 0 0 $X=98880 $Y=242730
X257 1 MASCO__B33 $T=102460 242730 0 0 $X=102460 $Y=242730
X258 1 MASCO__B33 $T=131180 38950 0 0 $X=131180 $Y=38950
X259 1 MASCO__B33 $T=134760 38950 0 0 $X=134760 $Y=38950
X260 1 MASCO__B33 $T=163480 242730 0 0 $X=163480 $Y=242730
X261 1 MASCO__B33 $T=167060 242730 0 0 $X=167060 $Y=242730
X262 1 MASCO__B33 $T=195780 38950 0 0 $X=195780 $Y=38950
X263 1 MASCO__B33 $T=199360 38950 0 0 $X=199360 $Y=38950
X264 1 MASCO__B33 $T=228080 242730 0 0 $X=228080 $Y=242730
X265 1 MASCO__B33 $T=231660 242730 0 0 $X=231660 $Y=242730
X266 1 MASCO__B33 $T=260380 242730 0 0 $X=260380 $Y=242730
X267 1 MASCO__B33 $T=263960 242730 0 0 $X=263960 $Y=242730
X268 1 MASCO__B33 $T=292680 38950 0 0 $X=292680 $Y=38950
X269 1 MASCO__B33 $T=296260 38950 0 0 $X=296260 $Y=38950
X270 1 MASCO__B33 $T=324980 242730 0 0 $X=324980 $Y=242730
X271 1 MASCO__B33 $T=328560 242730 0 0 $X=328560 $Y=242730
X272 1 MASCO__B33 $T=357280 38950 0 0 $X=357280 $Y=38950
X273 1 MASCO__B33 $T=360860 38950 0 0 $X=360860 $Y=38950
X274 1 MASCO__B33 $T=389580 242730 0 0 $X=389580 $Y=242730
X275 1 MASCO__B33 $T=393160 242730 0 0 $X=393160 $Y=242730
X276 5 1 MASCO__B34 $T=66580 177000 0 0 $X=66580 $Y=177000
X277 5 1 MASCO__B34 $T=70160 177000 0 0 $X=70160 $Y=177000
X278 1 1 MASCO__B34 $T=98880 177000 0 0 $X=98880 $Y=177000
X279 1 1 MASCO__B34 $T=102460 177000 0 0 $X=102460 $Y=177000
X280 5 1 MASCO__B34 $T=131180 177000 0 0 $X=131180 $Y=177000
X281 5 1 MASCO__B34 $T=134760 177000 0 0 $X=134760 $Y=177000
X282 1 1 MASCO__B34 $T=163480 177000 0 0 $X=163480 $Y=177000
X283 1 1 MASCO__B34 $T=167060 177000 0 0 $X=167060 $Y=177000
X284 5 1 MASCO__B34 $T=195780 177000 0 0 $X=195780 $Y=177000
X285 5 1 MASCO__B34 $T=199360 177000 0 0 $X=199360 $Y=177000
X286 1 1 MASCO__B34 $T=228080 177000 0 0 $X=228080 $Y=177000
X287 1 1 MASCO__B34 $T=231660 177000 0 0 $X=231660 $Y=177000
X288 1 1 MASCO__B34 $T=260380 177000 0 0 $X=260380 $Y=177000
X289 1 1 MASCO__B34 $T=263960 177000 0 0 $X=263960 $Y=177000
X290 5 1 MASCO__B34 $T=292680 177000 0 0 $X=292680 $Y=177000
X291 5 1 MASCO__B34 $T=296260 177000 0 0 $X=296260 $Y=177000
X292 1 1 MASCO__B34 $T=324980 177000 0 0 $X=324980 $Y=177000
X293 1 1 MASCO__B34 $T=328560 177000 0 0 $X=328560 $Y=177000
X294 5 1 MASCO__B34 $T=357280 177000 0 0 $X=357280 $Y=177000
X295 5 1 MASCO__B34 $T=360860 177000 0 0 $X=360860 $Y=177000
X296 1 1 MASCO__B34 $T=389580 177000 0 0 $X=389580 $Y=177000
X297 1 1 MASCO__B34 $T=393160 177000 0 0 $X=393160 $Y=177000
X298 1 1 MASCO__B35 $T=66580 73500 0 0 $X=66580 $Y=73500
X299 1 1 MASCO__B35 $T=70160 73500 0 0 $X=70160 $Y=73500
X300 5 1 MASCO__B35 $T=98880 73500 0 0 $X=98880 $Y=73500
X301 5 1 MASCO__B35 $T=102460 73500 0 0 $X=102460 $Y=73500
X302 1 1 MASCO__B35 $T=131180 73500 0 0 $X=131180 $Y=73500
X303 1 1 MASCO__B35 $T=134760 73500 0 0 $X=134760 $Y=73500
X304 5 1 MASCO__B35 $T=163480 73500 0 0 $X=163480 $Y=73500
X305 5 1 MASCO__B35 $T=167060 73500 0 0 $X=167060 $Y=73500
X306 1 1 MASCO__B35 $T=195780 73500 0 0 $X=195780 $Y=73500
X307 1 1 MASCO__B35 $T=199360 73500 0 0 $X=199360 $Y=73500
X308 5 1 MASCO__B35 $T=260380 73500 0 0 $X=260380 $Y=73500
X309 5 1 MASCO__B35 $T=263960 73500 0 0 $X=263960 $Y=73500
X310 1 1 MASCO__B35 $T=292680 73500 0 0 $X=292680 $Y=73500
X311 1 1 MASCO__B35 $T=296260 73500 0 0 $X=296260 $Y=73500
X312 5 1 MASCO__B35 $T=324980 73500 0 0 $X=324980 $Y=73500
X313 5 1 MASCO__B35 $T=328560 73500 0 0 $X=328560 $Y=73500
X314 1 1 MASCO__B35 $T=357280 73500 0 0 $X=357280 $Y=73500
X315 1 1 MASCO__B35 $T=360860 73500 0 0 $X=360860 $Y=73500
X316 5 1 MASCO__B35 $T=389580 73500 0 0 $X=389580 $Y=73500
X317 5 1 MASCO__B35 $T=393160 73500 0 0 $X=393160 $Y=73500
X318 4 1 MASCO__B39 $T=0 51415 0 0 $X=0 $Y=51415
X319 4 1 MASCO__B39 $T=0 84375 0 0 $X=0 $Y=84375
X320 4 1 MASCO__B39 $T=0 117335 0 0 $X=0 $Y=117335
X321 4 1 MASCO__B39 $T=0 150295 0 0 $X=0 $Y=150295
X322 4 1 MASCO__B39 $T=0 183255 0 0 $X=0 $Y=183255
X323 4 1 MASCO__B39 $T=0 216215 0 0 $X=0 $Y=216215
X324 4 1 MASCO__B39 $T=53800 5 0 0 $X=53800 $Y=5
X325 4 1 MASCO__B39 $T=53800 272950 0 0 $X=53800 $Y=272950
X326 4 1 MASCO__B39 $T=86760 5 0 0 $X=86760 $Y=5
X327 4 1 MASCO__B39 $T=86760 272950 0 0 $X=86760 $Y=272950
X328 4 1 MASCO__B39 $T=119720 5 0 0 $X=119720 $Y=5
X329 4 1 MASCO__B39 $T=119720 272950 0 0 $X=119720 $Y=272950
X330 4 1 MASCO__B39 $T=152680 5 0 0 $X=152680 $Y=5
X331 4 1 MASCO__B39 $T=152680 272950 0 0 $X=152680 $Y=272950
X332 4 1 MASCO__B39 $T=185640 5 0 0 $X=185640 $Y=5
X333 4 1 MASCO__B39 $T=185640 272950 0 0 $X=185640 $Y=272950
X334 4 1 MASCO__B39 $T=218600 5 0 0 $X=218600 $Y=5
X335 4 1 MASCO__B39 $T=218600 272950 0 0 $X=218600 $Y=272950
X336 4 1 MASCO__B39 $T=251560 5 0 0 $X=251560 $Y=5
X337 4 1 MASCO__B39 $T=251560 272950 0 0 $X=251560 $Y=272950
X338 4 1 MASCO__B39 $T=284520 5 0 0 $X=284520 $Y=5
X339 4 1 MASCO__B39 $T=284520 272950 0 0 $X=284520 $Y=272950
X340 4 1 MASCO__B39 $T=317480 5 0 0 $X=317480 $Y=5
X341 4 1 MASCO__B39 $T=317480 272950 0 0 $X=317480 $Y=272950
X342 4 1 MASCO__B39 $T=350440 5 0 0 $X=350440 $Y=5
X343 4 1 MASCO__B39 $T=350440 272950 0 0 $X=350440 $Y=272950
X344 4 1 MASCO__B39 $T=428960 51415 0 0 $X=428960 $Y=51415
X345 4 1 MASCO__B39 $T=428960 84375 0 0 $X=428960 $Y=84375
X346 4 1 MASCO__B39 $T=428960 117335 0 0 $X=428960 $Y=117335
X347 4 1 MASCO__B39 $T=428960 150295 0 0 $X=428960 $Y=150295
X348 4 1 MASCO__B39 $T=428960 183255 0 0 $X=428960 $Y=183255
X349 4 1 MASCO__B39 $T=428960 216215 0 0 $X=428960 $Y=216215
.ends CurrretMirrorx10_HV

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: rpp1k1_CDNS_173                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt rpp1k1_CDNS_173 1 2 3
** N=3 EP=3 FDC=1
R0 2 1 L=0.00011122 W=2e-06 $[rpp1k1] $X=-2220 $Y=0 $dt=244
.ends rpp1k1_CDNS_173

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: rpp1k1_CDNS_174                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt rpp1k1_CDNS_174 1 2
** N=2 EP=2 FDC=1
R0 2 1 L=0.00036998 W=2e-06 $[rpp1k1] $X=-2220 $Y=0 $dt=244
.ends rpp1k1_CDNS_174

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: HVMOS_GateRingM1                                *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt HVMOS_GateRingM1 1 2
** N=2 EP=2 FDC=0
.ends HVMOS_GateRingM1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: AND2HDX0                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt AND2HDX0 1 2 3 4 5
*.DEVICECLIMB
** N=7 EP=5 FDC=6
M0 6 3 7 2 ne L=1.8e-07 W=4.2e-07 AD=5.25e-14 AS=2.016e-13 PD=6.7e-07 PS=1.8e-06 $X=620 $Y=1130 $dt=0
M1 2 4 6 2 ne L=1.8e-07 W=4.2e-07 AD=4.554e-13 AS=5.25e-14 PD=2.25e-06 PS=6.7e-07 $X=1050 $Y=1130 $dt=0
M2 5 7 2 2 ne L=1.8e-07 W=4.2e-07 AD=2.016e-13 AS=4.554e-13 PD=1.8e-06 PS=2.25e-06 $X=2000 $Y=1130 $dt=0
M3 1 3 7 1 pe L=1.8e-07 W=7.2e-07 AD=6.23467e-13 AS=1.944e-13 PD=3.12667e-06 PS=1.26e-06 $X=515 $Y=2580 $dt=1
M4 1 4 7 1 pe L=1.8e-07 W=7.2e-07 AD=6.23467e-13 AS=1.944e-13 PD=3.12667e-06 PS=1.26e-06 $X=1235 $Y=2580 $dt=1
M5 5 7 1 1 pe L=1.8e-07 W=7.2e-07 AD=3.456e-13 AS=6.23467e-13 PD=2.4e-06 PS=3.12667e-06 $X=2000 $Y=2580 $dt=1
.ends AND2HDX0

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: IN_3VX2                                         *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt IN_3VX2 1 2 3 4
*.DEVICECLIMB
** N=4 EP=4 FDC=4
M0 4 3 2 2 ne3 L=3.5e-07 W=4.8e-07 AD=1.296e-13 AS=4.408e-13 PD=1.02e-06 PS=3.52e-06 $X=500 $Y=1070 $dt=83
M1 2 3 4 2 ne3 L=3.5e-07 W=4.8e-07 AD=4.408e-13 AS=1.296e-13 PD=3.52e-06 PS=1.02e-06 $X=1390 $Y=1070 $dt=83
M2 4 3 1 1 pe3 L=3.00472e-07 W=1.45971e-06 AD=2.751e-13 AS=8.151e-13 PD=1.87971e-06 PS=4.50971e-06 $X=560 $Y=2410 $dt=86
M3 1 3 4 1 pe3 L=3.00472e-07 W=1.45971e-06 AD=8.01e-13 AS=2.751e-13 PD=4.48971e-06 PS=1.87971e-06 $X=1400 $Y=2410 $dt=86
.ends IN_3VX2

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: LSHVT18U3VX1                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt LSHVT18U3VX1 1 2 3 4 5
*.DEVICECLIMB
** N=10 EP=5 FDC=10
M0 8 4 2 2 ne3 L=3.5e-07 W=4.2e-07 AD=2.016e-13 AS=3.654e-13 PD=1.8e-06 PS=2.58e-06 $X=660 $Y=660 $dt=83
M1 2 8 6 2 ne3 L=3.5e-07 W=1.31e-06 AD=3.537e-13 AS=6.187e-13 PD=1.85e-06 PS=3.61e-06 $X=2345 $Y=660 $dt=83
M2 7 4 2 2 ne3 L=3.5e-07 W=1.31e-06 AD=6.288e-13 AS=3.537e-13 PD=3.58e-06 PS=1.85e-06 $X=3235 $Y=660 $dt=83
M3 5 7 2 2 ne3 L=3.5e-07 W=8.9e-07 AD=4.272e-13 AS=1.0128e-12 PD=2.74e-06 PS=4.17e-06 $X=5190 $Y=660 $dt=83
M4 8 4 3 1 pe3 L=3.0008e-07 W=1.47627e-06 AD=6.24563e-13 AS=5.264e-13 PD=3.97406e-06 PS=3.68627e-06 $X=620 $Y=2410 $dt=86
M5 10 7 1 1 pe3 L=3e-07 W=4.2e-07 AD=5.25e-14 AS=3.086e-13 PD=6.7e-07 PS=2.7e-06 $X=1995 $Y=3060 $dt=86
M6 6 8 10 1 pe3 L=3e-07 W=4.2e-07 AD=2.6775e-13 AS=5.25e-14 PD=2.31071e-06 PS=6.7e-07 $X=2545 $Y=3060 $dt=86
M7 9 4 7 1 pe3 L=3e-07 W=4.2e-07 AD=5.25e-14 AS=2.32287e-13 PD=6.7e-07 PS=1.98778e-06 $X=3970 $Y=3400 $dt=86
M8 1 6 9 1 pe3 L=3e-07 W=4.2e-07 AD=1.30176e-13 AS=5.25e-14 PD=8.55707e-07 PS=6.7e-07 $X=4520 $Y=3400 $dt=86
M9 5 7 1 1 pe3 L=3.00472e-07 W=1.45971e-06 AD=5.718e-13 AS=4.52424e-13 PD=3.70971e-06 PS=2.974e-06 $X=5240 $Y=2410 $dt=86
.ends LSHVT18U3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: CurrentSource_All_ST                            *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt CurrentSource_All_ST 1 2 3 4 5 6 7 8 9 10
+ 11 12 13
** N=43 EP=13 FDC=628
X0 8 VIA1_C_CDNS_42 $T=291875 -579560 0 0 $X=291375 $Y=-579750
X1 8 VIA1_C_CDNS_42 $T=291875 -575640 0 0 $X=291375 $Y=-575830
X2 8 VIA1_C_CDNS_42 $T=291875 -570600 0 0 $X=291375 $Y=-570790
X3 8 VIA1_C_CDNS_42 $T=291875 -566680 0 0 $X=291375 $Y=-566870
X4 8 VIA1_C_CDNS_42 $T=291875 -561640 0 0 $X=291375 $Y=-561830
X5 2 VIA1_C_CDNS_43 $T=289965 -582080 1 0 $X=288965 $Y=-582480
X6 2 VIA1_C_CDNS_43 $T=289965 -573120 1 0 $X=288965 $Y=-573520
X7 2 VIA1_C_CDNS_43 $T=289965 -564160 1 0 $X=288965 $Y=-564560
X8 8 VIA1_C_CDNS_43 $T=462380 -463765 0 0 $X=461380 $Y=-464165
X9 10 VIA1_C_CDNS_44 $T=298755 -580390 0 0 $X=298005 $Y=-580840
X10 10 VIA1_C_CDNS_44 $T=298755 -574810 0 0 $X=298005 $Y=-575260
X11 10 VIA1_C_CDNS_44 $T=298755 -571430 0 0 $X=298005 $Y=-571880
X12 10 VIA1_C_CDNS_44 $T=298755 -565850 0 0 $X=298005 $Y=-566300
X13 10 VIA1_C_CDNS_44 $T=298755 -562470 0 0 $X=298005 $Y=-562920
X14 9 VIA1_C_CDNS_45 $T=296710 -582080 0 0 $X=295960 $Y=-582480
X15 9 VIA1_C_CDNS_45 $T=296710 -573120 0 0 $X=295960 $Y=-573520
X16 9 VIA1_C_CDNS_45 $T=296710 -564160 0 0 $X=295960 $Y=-564560
X17 14 VIA1_C_CDNS_46 $T=307605 -579580 0 0 $X=307375 $Y=-580070
X18 15 VIA1_C_CDNS_46 $T=307605 -575620 0 0 $X=307375 $Y=-576110
X19 16 VIA1_C_CDNS_46 $T=307605 -570620 0 0 $X=307375 $Y=-571110
X20 17 VIA1_C_CDNS_46 $T=307605 -566655 0 0 $X=307375 $Y=-567145
X21 18 VIA1_C_CDNS_46 $T=307605 -561660 0 0 $X=307375 $Y=-562150
X22 19 VIA1_C_CDNS_46 $T=606070 -372855 0 0 $X=605840 $Y=-373345
X23 19 VIA1_C_CDNS_46 $T=618970 -372855 0 0 $X=618740 $Y=-373345
X24 19 VIA1_C_CDNS_46 $T=625190 -372855 0 0 $X=624960 $Y=-373345
X25 19 VIA1_C_CDNS_46 $T=631410 -372855 0 0 $X=631180 $Y=-373345
X26 20 VIA1_C_CDNS_46 $T=643355 -548695 0 0 $X=643125 $Y=-549185
X27 20 VIA1_C_CDNS_46 $T=643355 -499875 0 0 $X=643125 $Y=-500365
X28 19 VIA1_C_CDNS_46 $T=643390 -372855 0 0 $X=643160 $Y=-373345
X29 19 VIA1_C_CDNS_46 $T=649610 -372855 0 0 $X=649380 $Y=-373345
X30 21 VIA1_C_CDNS_46 $T=677290 -548695 0 0 $X=677060 $Y=-549185
X31 22 VIA1_C_CDNS_46 $T=677290 -470055 0 0 $X=677060 $Y=-470545
X32 22 VIA1_C_CDNS_46 $T=677290 -423735 0 0 $X=677060 $Y=-424225
X33 22 VIA1_C_CDNS_46 $T=677290 -413915 0 0 $X=677060 $Y=-414405
X34 22 VIA1_C_CDNS_46 $T=677290 -345090 0 0 $X=677060 $Y=-345580
X35 23 VIA2_C_CDNS_47 $T=450130 -458010 0 0 $X=449380 $Y=-458760
X36 12 VIA2_C_CDNS_47 $T=589560 -340705 0 0 $X=588810 $Y=-341455
X37 23 VIA2_C_CDNS_48 $T=450130 -390570 0 0 $X=449380 $Y=-391060
X38 24 VIA2_C_CDNS_48 $T=599875 -432430 0 0 $X=599125 $Y=-432920
X39 24 VIA2_C_CDNS_48 $T=611775 -432430 0 0 $X=611025 $Y=-432920
X40 19 VIA2_C_CDNS_48 $T=632315 -438675 0 0 $X=631565 $Y=-439165
X41 19 VIA2_C_CDNS_48 $T=644215 -438675 0 0 $X=643465 $Y=-439165
X42 25 VIA2_C_CDNS_49 $T=375850 -570945 0 0 $X=375360 $Y=-572215
X43 25 VIA2_C_CDNS_49 $T=477290 -562425 0 0 $X=476800 $Y=-563695
X44 19 VIA1_C_CDNS_56 $T=618970 -399755 0 0 $X=618570 $Y=-399945
X45 19 VIA1_C_CDNS_56 $T=625190 -399755 0 0 $X=624790 $Y=-399945
X46 19 VIA1_C_CDNS_56 $T=637630 -399755 0 0 $X=637230 $Y=-399945
X47 19 VIA1_C_CDNS_57 $T=593630 -399755 0 0 $X=593490 $Y=-400205
X48 19 VIA1_C_CDNS_57 $T=593630 -372855 0 0 $X=593490 $Y=-373305
X49 19 VIA1_C_CDNS_57 $T=593630 -345955 0 0 $X=593490 $Y=-346405
X50 1 VIA1_C_CDNS_57 $T=594090 -412615 0 0 $X=593950 $Y=-413065
X51 1 VIA1_C_CDNS_57 $T=594090 -385635 0 0 $X=593950 $Y=-386085
X52 1 VIA1_C_CDNS_57 $T=594090 -358735 0 0 $X=593950 $Y=-359185
X53 1 VIA1_C_CDNS_57 $T=594090 -333175 0 0 $X=593950 $Y=-333625
X54 1 VIA1_C_CDNS_57 $T=600310 -412615 0 0 $X=600170 $Y=-413065
X55 1 VIA1_C_CDNS_57 $T=600310 -385635 0 0 $X=600170 $Y=-386085
X56 1 VIA1_C_CDNS_57 $T=600310 -358735 0 0 $X=600170 $Y=-359185
X57 1 VIA1_C_CDNS_57 $T=600310 -333175 0 0 $X=600170 $Y=-333625
X58 12 VIA1_C_CDNS_57 $T=605345 -360075 0 0 $X=605205 $Y=-360525
X59 19 VIA1_C_CDNS_57 $T=605955 -345955 0 0 $X=605815 $Y=-346405
X60 1 VIA1_C_CDNS_57 $T=606530 -412615 0 0 $X=606390 $Y=-413065
X61 1 VIA1_C_CDNS_57 $T=606530 -385635 0 0 $X=606390 $Y=-386085
X62 19 VIA1_C_CDNS_57 $T=606530 -345955 0 0 $X=606390 $Y=-346405
X63 1 VIA1_C_CDNS_57 $T=606530 -333175 0 0 $X=606390 $Y=-333625
X64 1 VIA1_C_CDNS_57 $T=607255 -358735 0 0 $X=607115 $Y=-359185
X65 12 VIA1_C_CDNS_57 $T=611565 -386975 0 0 $X=611425 $Y=-387425
X66 12 VIA1_C_CDNS_57 $T=612290 -360075 0 0 $X=612150 $Y=-360525
X67 19 VIA1_C_CDNS_57 $T=612290 -345955 0 0 $X=612150 $Y=-346405
X68 1 VIA1_C_CDNS_57 $T=612750 -412615 0 0 $X=612610 $Y=-413065
X69 19 VIA1_C_CDNS_57 $T=612750 -372855 0 0 $X=612610 $Y=-373305
X70 1 VIA1_C_CDNS_57 $T=612750 -358735 0 0 $X=612610 $Y=-359185
X71 1 VIA1_C_CDNS_57 $T=612750 -333175 0 0 $X=612610 $Y=-333625
X72 1 VIA1_C_CDNS_57 $T=613475 -385635 0 0 $X=613335 $Y=-386085
X73 19 VIA1_C_CDNS_57 $T=618395 -345955 0 0 $X=618255 $Y=-346405
X74 12 VIA1_C_CDNS_57 $T=618510 -386975 0 0 $X=618370 $Y=-387425
X75 12 VIA1_C_CDNS_57 $T=618510 -360075 0 0 $X=618370 $Y=-360525
X76 1 VIA1_C_CDNS_57 $T=618970 -412615 0 0 $X=618830 $Y=-413065
X77 19 VIA1_C_CDNS_57 $T=618970 -345955 0 0 $X=618830 $Y=-346405
X78 1 VIA1_C_CDNS_57 $T=618970 -333175 0 0 $X=618830 $Y=-333625
X79 19 VIA1_C_CDNS_57 $T=624615 -345955 0 0 $X=624475 $Y=-346405
X80 12 VIA1_C_CDNS_57 $T=624730 -386975 0 0 $X=624590 $Y=-387425
X81 12 VIA1_C_CDNS_57 $T=624730 -360075 0 0 $X=624590 $Y=-360525
X82 1 VIA1_C_CDNS_57 $T=625190 -412615 0 0 $X=625050 $Y=-413065
X83 19 VIA1_C_CDNS_57 $T=625190 -345955 0 0 $X=625050 $Y=-346405
X84 1 VIA1_C_CDNS_57 $T=625190 -333175 0 0 $X=625050 $Y=-333625
X85 12 VIA1_C_CDNS_57 $T=630225 -386975 0 0 $X=630085 $Y=-387425
X86 19 VIA1_C_CDNS_57 $T=630950 -399755 0 0 $X=630810 $Y=-400205
X87 12 VIA1_C_CDNS_57 $T=630950 -360075 0 0 $X=630810 $Y=-360525
X88 19 VIA1_C_CDNS_57 $T=630950 -345955 0 0 $X=630810 $Y=-346405
X89 1 VIA1_C_CDNS_57 $T=631410 -412615 0 0 $X=631270 $Y=-413065
X90 1 VIA1_C_CDNS_57 $T=631410 -358735 0 0 $X=631270 $Y=-359185
X91 1 VIA1_C_CDNS_57 $T=631410 -333175 0 0 $X=631270 $Y=-333625
X92 1 VIA1_C_CDNS_57 $T=632135 -385635 0 0 $X=631995 $Y=-386085
X93 12 VIA1_C_CDNS_57 $T=636445 -360075 0 0 $X=636305 $Y=-360525
X94 19 VIA1_C_CDNS_57 $T=637055 -345955 0 0 $X=636915 $Y=-346405
X95 12 VIA1_C_CDNS_57 $T=637170 -386975 0 0 $X=637030 $Y=-387425
X96 19 VIA1_C_CDNS_57 $T=637170 -372855 0 0 $X=637030 $Y=-373305
X97 1 VIA1_C_CDNS_57 $T=637630 -412615 0 0 $X=637490 $Y=-413065
X98 1 VIA1_C_CDNS_57 $T=637630 -385635 0 0 $X=637490 $Y=-386085
X99 19 VIA1_C_CDNS_57 $T=637630 -345955 0 0 $X=637490 $Y=-346405
X100 1 VIA1_C_CDNS_57 $T=637630 -333175 0 0 $X=637490 $Y=-333625
X101 1 VIA1_C_CDNS_57 $T=638355 -358735 0 0 $X=638215 $Y=-359185
X102 19 VIA1_C_CDNS_57 $T=643390 -399755 0 0 $X=643250 $Y=-400205
X103 19 VIA1_C_CDNS_57 $T=643390 -345955 0 0 $X=643250 $Y=-346405
X104 1 VIA1_C_CDNS_57 $T=643850 -412615 0 0 $X=643710 $Y=-413065
X105 1 VIA1_C_CDNS_57 $T=643850 -385635 0 0 $X=643710 $Y=-386085
X106 1 VIA1_C_CDNS_57 $T=643850 -358735 0 0 $X=643710 $Y=-359185
X107 1 VIA1_C_CDNS_57 $T=643850 -333175 0 0 $X=643710 $Y=-333625
X108 19 VIA1_C_CDNS_57 $T=649610 -399755 0 0 $X=649470 $Y=-400205
X109 1 VIA1_C_CDNS_57 $T=650070 -412615 0 0 $X=649930 $Y=-413065
X110 1 VIA1_C_CDNS_57 $T=650070 -385635 0 0 $X=649930 $Y=-386085
X111 1 VIA1_C_CDNS_57 $T=650070 -358735 0 0 $X=649930 $Y=-359185
X112 1 VIA1_C_CDNS_57 $T=650070 -333175 0 0 $X=649930 $Y=-333625
X113 19 VIA2_C_CDNS_58 $T=585380 -399755 0 0 $X=584930 $Y=-400155
X114 19 VIA2_C_CDNS_58 $T=585380 -372855 0 0 $X=584930 $Y=-373255
X115 19 VIA2_C_CDNS_58 $T=585380 -345955 0 0 $X=584930 $Y=-346355
X116 19 VIA2_C_CDNS_58 $T=658240 -399755 0 0 $X=657790 $Y=-400155
X117 19 VIA2_C_CDNS_58 $T=658240 -372855 0 0 $X=657790 $Y=-373255
X118 19 VIA2_C_CDNS_58 $T=658240 -345955 0 0 $X=657790 $Y=-346355
X119 1 11 23 Ext_Iref_ST $T=449360 -356980 1 0 $X=449990 $Y=-424390
X120 26 VIA1_C_CDNS_77 $T=483780 -469155 0 0 $X=483030 $Y=-469385
X121 26 VIA1_C_CDNS_77 $T=483780 -457165 0 0 $X=483030 $Y=-457395
X122 1 9 23 14 25 15 16 17 18 Idac_5bit_ST_V3 $T=247420 -582970 0 0 $X=239880 $Y=-582645
X123 1 1 VIA3_C_CDNS_81 $T=675500 -514285 0 0 $X=674410 $Y=-541985
X124 1 1 VIA3_C_CDNS_81 $T=679080 -514285 0 0 $X=677990 $Y=-541985
X125 1 1 VIA2_C_CDNS_82 $T=675500 -514285 0 0 $X=674410 $Y=-541985
X126 1 1 VIA2_C_CDNS_82 $T=679080 -514285 0 0 $X=677990 $Y=-541985
X127 24 1 VIA3_C_CDNS_84 $T=510750 -511040 0 0 $X=509660 $Y=-513540
X128 24 1 VIA3_C_CDNS_84 $T=514330 -511040 0 0 $X=513240 $Y=-513540
X129 24 1 VIA3_C_CDNS_84 $T=522650 -511040 0 0 $X=521560 $Y=-513540
X130 24 1 VIA3_C_CDNS_84 $T=526230 -511040 0 0 $X=525140 $Y=-513540
X131 24 1 VIA3_C_CDNS_84 $T=534550 -511040 0 0 $X=533460 $Y=-513540
X132 24 1 VIA3_C_CDNS_84 $T=538130 -511040 0 0 $X=537040 $Y=-513540
X133 24 1 VIA3_C_CDNS_84 $T=546450 -511040 0 0 $X=545360 $Y=-513540
X134 24 1 VIA3_C_CDNS_84 $T=550030 -511040 0 0 $X=548940 $Y=-513540
X135 24 1 VIA3_C_CDNS_84 $T=558350 -511040 0 0 $X=557260 $Y=-513540
X136 24 1 VIA3_C_CDNS_84 $T=561930 -511040 0 0 $X=560840 $Y=-513540
X137 9 VIA1_C_CDNS_85 $T=493905 -460295 0 0 $X=492905 $Y=-461295
X138 19 VIA1_C_CDNS_88 $T=599850 -399755 0 0 $X=599710 $Y=-400255
X139 19 VIA1_C_CDNS_88 $T=599850 -372855 0 0 $X=599710 $Y=-373355
X140 19 VIA1_C_CDNS_88 $T=599850 -345955 0 0 $X=599710 $Y=-346455
X141 19 VIA1_C_CDNS_88 $T=606070 -399755 0 0 $X=605930 $Y=-400255
X142 19 VIA1_C_CDNS_88 $T=612290 -399755 0 0 $X=612150 $Y=-400255
X143 19 VIA1_C_CDNS_88 $T=649610 -345955 0 0 $X=649470 $Y=-346455
X144 27 1 VIA2_C_CDNS_89 $T=506400 -399555 0 0 $X=504520 $Y=-408935
X145 12 1 VIA2_C_CDNS_89 $T=506400 -354655 0 0 $X=504520 $Y=-364035
X146 28 1 VIA2_C_CDNS_89 $T=536300 -399555 0 0 $X=534420 $Y=-408935
X147 12 1 VIA2_C_CDNS_89 $T=536300 -354655 0 0 $X=534420 $Y=-364035
X148 29 1 VIA2_C_CDNS_89 $T=566200 -399555 0 0 $X=564320 $Y=-408935
X149 12 1 VIA2_C_CDNS_89 $T=566200 -354655 0 0 $X=564320 $Y=-364035
X150 27 1 VIA3_C_CDNS_90 $T=506400 -399555 0 0 $X=504520 $Y=-408935
X151 12 1 VIA3_C_CDNS_90 $T=506400 -354655 0 0 $X=504520 $Y=-364035
X152 28 1 VIA3_C_CDNS_90 $T=536300 -399555 0 0 $X=534420 $Y=-408935
X153 12 1 VIA3_C_CDNS_90 $T=536300 -354655 0 0 $X=534420 $Y=-364035
X154 29 1 VIA3_C_CDNS_90 $T=566200 -399555 0 0 $X=564320 $Y=-408935
X155 12 1 VIA3_C_CDNS_90 $T=566200 -354655 0 0 $X=564320 $Y=-364035
X156 30 VIA2_C_CDNS_91 $T=506400 -414155 0 0 $X=505390 $Y=-415165
X157 30 VIA2_C_CDNS_91 $T=506400 -384955 1 0 $X=505390 $Y=-385965
X158 28 VIA2_C_CDNS_91 $T=506400 -369255 0 0 $X=505390 $Y=-370265
X159 28 VIA2_C_CDNS_91 $T=506400 -340055 1 0 $X=505390 $Y=-341065
X160 30 VIA2_C_CDNS_91 $T=536300 -414155 0 0 $X=535290 $Y=-415165
X161 30 VIA2_C_CDNS_91 $T=536300 -384955 1 0 $X=535290 $Y=-385965
X162 28 VIA2_C_CDNS_91 $T=536300 -369255 0 0 $X=535290 $Y=-370265
X163 28 VIA2_C_CDNS_91 $T=536300 -340055 1 0 $X=535290 $Y=-341065
X164 30 VIA2_C_CDNS_91 $T=566200 -414155 0 0 $X=565190 $Y=-415165
X165 28 VIA2_C_CDNS_91 $T=566200 -369255 0 0 $X=565190 $Y=-370265
X166 28 VIA2_C_CDNS_91 $T=566200 -340055 1 0 $X=565190 $Y=-341065
X167 22 1 VIA2_C_CDNS_92 $T=500600 -426235 0 0 $X=498290 $Y=-428545
X168 27 1 VIA2_C_CDNS_92 $T=500600 -377105 0 0 $X=498290 $Y=-379415
X169 22 1 VIA2_C_CDNS_92 $T=512200 -426235 0 0 $X=509890 $Y=-428545
X170 27 1 VIA2_C_CDNS_92 $T=512200 -377105 0 0 $X=509890 $Y=-379415
X171 20 1 VIA2_C_CDNS_92 $T=560400 -419490 0 0 $X=558090 $Y=-421800
X172 29 1 VIA2_C_CDNS_92 $T=560400 -377105 0 0 $X=558090 $Y=-379415
X173 20 1 VIA2_C_CDNS_92 $T=572000 -419490 0 0 $X=569690 $Y=-421800
X174 29 1 VIA2_C_CDNS_92 $T=572000 -377105 0 0 $X=569690 $Y=-379415
X175 20 1 VIA2_C_CDNS_92 $T=658055 -419680 0 0 $X=655745 $Y=-421990
X176 30 VIA2_C_CDNS_93 $T=521350 -436260 0 0 $X=520080 $Y=-437530
X177 30 VIA2_C_CDNS_93 $T=521350 -414155 0 0 $X=520080 $Y=-415425
X178 30 VIA2_C_CDNS_93 $T=521350 -384955 1 0 $X=520080 $Y=-386225
X179 28 VIA2_C_CDNS_93 $T=521350 -369255 0 0 $X=520080 $Y=-370525
X180 28 VIA2_C_CDNS_93 $T=521350 -340055 1 0 $X=520080 $Y=-341325
X181 30 VIA2_C_CDNS_93 $T=551250 -436260 0 0 $X=549980 $Y=-437530
X182 30 VIA2_C_CDNS_93 $T=551250 -414155 0 0 $X=549980 $Y=-415425
X183 30 VIA2_C_CDNS_93 $T=551250 -384955 1 0 $X=549980 $Y=-386225
X184 28 VIA2_C_CDNS_93 $T=551250 -369255 0 0 $X=549980 $Y=-370525
X185 28 VIA2_C_CDNS_93 $T=551250 -340055 1 0 $X=549980 $Y=-341325
X186 30 1 VIA2_C_CDNS_94 $T=531000 -436260 0 0 $X=529210 $Y=-437530
X187 30 1 VIA2_C_CDNS_94 $T=531000 -414155 0 0 $X=529210 $Y=-415425
X188 30 1 VIA2_C_CDNS_94 $T=531000 -384955 1 0 $X=529210 $Y=-386225
X189 28 1 VIA2_C_CDNS_94 $T=531000 -369255 0 0 $X=529210 $Y=-370525
X190 28 1 VIA2_C_CDNS_94 $T=531000 -340055 1 0 $X=529210 $Y=-341325
X191 30 1 VIA2_C_CDNS_94 $T=541600 -436260 0 0 $X=539810 $Y=-437530
X192 30 1 VIA2_C_CDNS_94 $T=541600 -414155 0 0 $X=539810 $Y=-415425
X193 30 1 VIA2_C_CDNS_94 $T=541600 -384955 1 0 $X=539810 $Y=-386225
X194 28 1 VIA2_C_CDNS_94 $T=541600 -369255 0 0 $X=539810 $Y=-370525
X195 28 1 VIA2_C_CDNS_94 $T=541600 -340055 1 0 $X=539810 $Y=-341325
X196 27 1 VIA3_C_CDNS_95 $T=506400 -377105 0 0 $X=504610 $Y=-379415
X197 29 1 VIA3_C_CDNS_95 $T=566200 -377105 0 0 $X=564410 $Y=-379415
X198 31 1 VIA3_C_CDNS_95 $T=670330 -418930 0 0 $X=668540 $Y=-421240
X199 31 1 VIA3_C_CDNS_95 $T=684250 -418930 0 0 $X=682460 $Y=-421240
X200 32 VIA2_C_CDNS_96 $T=512540 -483765 0 0 $X=512310 $Y=-484255
X201 32 VIA2_C_CDNS_96 $T=512540 -443025 0 0 $X=512310 $Y=-443515
X202 32 VIA2_C_CDNS_96 $T=524440 -483765 0 0 $X=524210 $Y=-484255
X203 32 VIA2_C_CDNS_96 $T=524440 -443025 0 0 $X=524210 $Y=-443515
X204 32 VIA2_C_CDNS_96 $T=536340 -483765 0 0 $X=536110 $Y=-484255
X205 32 VIA2_C_CDNS_96 $T=536340 -443025 0 0 $X=536110 $Y=-443515
X206 32 VIA2_C_CDNS_96 $T=548240 -483765 0 0 $X=548010 $Y=-484255
X207 32 VIA2_C_CDNS_96 $T=548240 -443025 0 0 $X=548010 $Y=-443515
X208 32 VIA2_C_CDNS_96 $T=560140 -483765 0 0 $X=559910 $Y=-484255
X209 32 VIA2_C_CDNS_96 $T=560140 -443025 0 0 $X=559910 $Y=-443515
X210 19 VIA2_C_CDNS_96 $T=605825 -458770 0 0 $X=605595 $Y=-459260
X211 19 VIA2_C_CDNS_96 $T=605825 -438675 0 0 $X=605595 $Y=-439165
X212 9 VIA2_C_CDNS_96 $T=638250 -458770 0 0 $X=638020 $Y=-459260
X213 9 VIA2_C_CDNS_96 $T=638265 -442370 0 0 $X=638035 $Y=-442860
X214 32 VIA2_C_CDNS_97 $T=489655 -463410 0 0 $X=489165 $Y=-463900
X215 32 VIA2_C_CDNS_97 $T=503385 -483765 0 0 $X=502895 $Y=-484255
X216 32 VIA2_C_CDNS_97 $T=503385 -463405 0 0 $X=502895 $Y=-463895
X217 32 VIA2_C_CDNS_97 $T=503385 -443025 0 0 $X=502895 $Y=-443515
X218 19 VIA2_C_CDNS_97 $T=585380 -415215 0 0 $X=584890 $Y=-415705
X219 19 VIA2_C_CDNS_97 $T=621905 -458770 0 0 $X=621415 $Y=-459260
X220 19 VIA2_C_CDNS_97 $T=621905 -438675 0 0 $X=621415 $Y=-439165
X221 9 VIA2_C_CDNS_97 $T=628665 -458770 0 0 $X=628175 $Y=-459260
X222 9 VIA2_C_CDNS_97 $T=628665 -442370 0 0 $X=628175 $Y=-442860
X223 19 VIA2_C_CDNS_97 $T=658240 -415215 0 0 $X=657750 $Y=-415705
X224 30 1 VIA2_C_CDNS_98 $T=506590 -461395 0 0 $X=505630 $Y=-476395
X225 30 1 VIA2_C_CDNS_98 $T=518490 -461395 0 0 $X=517530 $Y=-476395
X226 30 1 VIA2_C_CDNS_98 $T=530390 -461395 0 0 $X=529430 $Y=-476395
X227 30 1 VIA2_C_CDNS_98 $T=542290 -461395 0 0 $X=541330 $Y=-476395
X228 30 1 VIA2_C_CDNS_98 $T=554190 -461395 0 0 $X=553230 $Y=-476395
X229 30 1 VIA2_C_CDNS_98 $T=566090 -461395 0 0 $X=565130 $Y=-476395
X230 30 1 VIA3_C_CDNS_99 $T=506590 -461395 0 0 $X=505630 $Y=-476395
X231 30 1 VIA3_C_CDNS_99 $T=518490 -461395 0 0 $X=517530 $Y=-476395
X232 30 1 VIA3_C_CDNS_99 $T=530390 -461395 0 0 $X=529430 $Y=-476395
X233 30 1 VIA3_C_CDNS_99 $T=542290 -461395 0 0 $X=541330 $Y=-476395
X234 30 1 VIA3_C_CDNS_99 $T=554190 -461395 0 0 $X=553230 $Y=-476395
X235 30 1 VIA3_C_CDNS_99 $T=566090 -461395 0 0 $X=565130 $Y=-476395
X236 30 VIA3_C_CDNS_100 $T=506590 -436260 0 0 $X=505840 $Y=-437530
X237 30 VIA3_C_CDNS_100 $T=518490 -436260 0 0 $X=517740 $Y=-437530
X238 30 VIA3_C_CDNS_100 $T=530390 -436260 0 0 $X=529640 $Y=-437530
X239 30 VIA3_C_CDNS_100 $T=542290 -436260 0 0 $X=541540 $Y=-437530
X240 30 VIA3_C_CDNS_100 $T=554190 -436260 0 0 $X=553440 $Y=-437530
X241 30 VIA3_C_CDNS_100 $T=566090 -436260 0 0 $X=565340 $Y=-437530
X242 30 VIA2_C_CDNS_101 $T=506400 -436260 0 0 $X=505390 $Y=-437530
X243 30 VIA2_C_CDNS_101 $T=536300 -436260 0 0 $X=535290 $Y=-437530
X244 30 VIA2_C_CDNS_101 $T=566200 -436260 0 0 $X=565190 $Y=-437530
X245 30 VIA2_C_CDNS_101 $T=566200 -384955 0 0 $X=565190 $Y=-386225
X246 32 VIA1_C_CDNS_102 $T=489655 -463410 0 0 $X=489165 $Y=-463900
X247 1 VIA1_C_CDNS_102 $T=580455 -412615 0 0 $X=579965 $Y=-413105
X248 1 VIA1_C_CDNS_102 $T=580470 -385635 0 0 $X=579980 $Y=-386125
X249 1 VIA1_C_CDNS_102 $T=580570 -358735 0 0 $X=580080 $Y=-359225
X250 9 VIA1_C_CDNS_102 $T=587345 -476320 0 0 $X=586855 $Y=-476810
X251 1 VIA1_C_CDNS_106 $T=604035 -471710 0 0 $X=603025 $Y=-472200
X252 1 VIA1_C_CDNS_106 $T=607615 -471710 0 0 $X=606605 $Y=-472200
X253 1 VIA1_C_CDNS_106 $T=636475 -471710 0 0 $X=635465 $Y=-472200
X254 1 VIA1_C_CDNS_106 $T=640055 -471710 0 0 $X=639045 $Y=-472200
X255 1 VIA1_C_CDNS_106 $T=675500 -552920 0 0 $X=674490 $Y=-553410
X256 1 VIA1_C_CDNS_106 $T=679080 -552940 0 0 $X=678070 $Y=-553430
X257 24 VIA2_C_CDNS_109 $T=510750 -432430 0 0 $X=509740 $Y=-432920
X258 24 VIA2_C_CDNS_109 $T=514330 -432430 0 0 $X=513320 $Y=-432920
X259 24 VIA2_C_CDNS_109 $T=526230 -432430 0 0 $X=525220 $Y=-432920
X260 24 VIA2_C_CDNS_109 $T=546450 -432430 0 0 $X=545440 $Y=-432920
X261 24 VIA2_C_CDNS_109 $T=558350 -432430 0 0 $X=557340 $Y=-432920
X262 24 VIA2_C_CDNS_109 $T=561930 -432430 0 0 $X=560920 $Y=-432920
X263 1 VIA2_C_CDNS_109 $T=675500 -552920 0 0 $X=674490 $Y=-553410
X264 1 VIA2_C_CDNS_109 $T=679080 -552940 0 0 $X=678070 $Y=-553430
X265 24 1 VIA2_C_CDNS_110 $T=510750 -511040 0 0 $X=509660 $Y=-513540
X266 24 1 VIA2_C_CDNS_110 $T=514330 -511040 0 0 $X=513240 $Y=-513540
X267 24 1 VIA2_C_CDNS_110 $T=522650 -511040 0 0 $X=521560 $Y=-513540
X268 24 1 VIA2_C_CDNS_110 $T=526230 -511040 0 0 $X=525140 $Y=-513540
X269 24 1 VIA2_C_CDNS_110 $T=534550 -511040 0 0 $X=533460 $Y=-513540
X270 24 1 VIA2_C_CDNS_110 $T=538130 -511040 0 0 $X=537040 $Y=-513540
X271 24 1 VIA2_C_CDNS_110 $T=546450 -511040 0 0 $X=545360 $Y=-513540
X272 24 1 VIA2_C_CDNS_110 $T=550030 -511040 0 0 $X=548940 $Y=-513540
X273 24 1 VIA2_C_CDNS_110 $T=558350 -511040 0 0 $X=557260 $Y=-513540
X274 24 1 VIA2_C_CDNS_110 $T=561930 -511040 0 0 $X=560840 $Y=-513540
X275 1 VIA3_C_CDNS_112 $T=675500 -552920 0 0 $X=674490 $Y=-553410
X276 1 VIA3_C_CDNS_112 $T=679080 -552940 0 0 $X=678070 $Y=-553430
X277 21 VIA2_C_CDNS_115 $T=677290 -548695 0 0 $X=677060 $Y=-551005
X278 22 VIA2_C_CDNS_115 $T=677290 -426045 0 0 $X=677060 $Y=-428355
X279 21 1 VIA2_C_CDNS_116 $T=670330 -548695 0 0 $X=668540 $Y=-551005
X280 22 1 VIA2_C_CDNS_116 $T=670330 -426045 0 0 $X=668540 $Y=-428355
X281 21 1 VIA2_C_CDNS_116 $T=684250 -548695 0 0 $X=682460 $Y=-551005
X282 22 1 VIA2_C_CDNS_116 $T=684250 -426045 0 0 $X=682460 $Y=-428355
X283 31 1 VIA2_C_CDNS_117 $T=675500 -418930 0 0 $X=674490 $Y=-421240
X284 31 1 VIA2_C_CDNS_117 $T=679080 -418930 0 0 $X=678070 $Y=-421240
X285 31 1 VIA3_C_CDNS_118 $T=670330 -446895 0 0 $X=668360 $Y=-463345
X286 31 1 VIA3_C_CDNS_118 $T=684250 -446895 0 0 $X=682280 $Y=-463345
X287 31 1 VIA2_C_CDNS_119 $T=670330 -446895 0 0 $X=668360 $Y=-463345
X288 31 1 VIA2_C_CDNS_119 $T=684250 -446895 0 0 $X=682280 $Y=-463345
X289 1 VIA2_C_CDNS_120 $T=587220 -412615 0 0 $X=586250 $Y=-413015
X290 1 VIA2_C_CDNS_120 $T=587220 -385635 0 0 $X=586250 $Y=-386035
X291 1 VIA2_C_CDNS_120 $T=587220 -358735 0 0 $X=586250 $Y=-359135
X292 1 VIA2_C_CDNS_120 $T=587220 -333175 0 0 $X=586250 $Y=-333575
X293 12 VIA2_C_CDNS_120 $T=589560 -386975 0 0 $X=588590 $Y=-387375
X294 12 VIA2_C_CDNS_120 $T=589560 -360075 0 0 $X=588590 $Y=-360475
X295 12 VIA2_C_CDNS_120 $T=654060 -386975 0 0 $X=653090 $Y=-387375
X296 12 VIA2_C_CDNS_120 $T=654060 -360075 0 0 $X=653090 $Y=-360475
X297 1 VIA2_C_CDNS_120 $T=656400 -412615 0 0 $X=655430 $Y=-413015
X298 1 VIA2_C_CDNS_120 $T=656400 -385635 0 0 $X=655430 $Y=-386035
X299 1 VIA2_C_CDNS_120 $T=656400 -358735 0 0 $X=655430 $Y=-359135
X300 1 VIA2_C_CDNS_120 $T=656400 -333175 0 0 $X=655430 $Y=-333575
X301 31 1 VIA3_C_CDNS_121 $T=670330 -467535 0 0 $X=668800 $Y=-469845
X302 31 1 VIA3_C_CDNS_121 $T=684250 -467535 0 0 $X=682720 $Y=-469845
X303 19 VIA1_C_CDNS_124 $T=618450 -399755 0 0 $X=617960 $Y=-399985
X304 19 VIA1_C_CDNS_124 $T=624670 -399755 0 0 $X=624180 $Y=-399985
X305 19 VIA1_C_CDNS_124 $T=637110 -399755 0 0 $X=636620 $Y=-399985
X306 1 21 1 21 nedia_bjt_CDNS_125 $T=677290 -534285 0 0 $X=661070 $Y=-553675
X307 1 22 31 22 nedia_bjt_CDNS_125 $T=677290 -399505 0 0 $X=661070 $Y=-418895
X308 1 31 22 21 nedia_bjt_CDNS_126 $T=677290 -455645 0 0 $X=661070 $Y=-475035
X309 1 30 32 24 nedia_bjt_CDNS_127 $T=512540 -478395 0 0 $X=496320 $Y=-497785
X310 9 1 10 8 32 LSHVT18U3VX2 $T=483220 -465375 0 0 $X=482790 $Y=-466015
X311 1 20 33 nedia_bjt_CDNS_128 $T=643355 -534285 0 0 $X=627135 $Y=-553675
X312 1 22 30 27 ped_bjt_CDNS_129 $T=506400 -407055 0 0 $X=491450 $Y=-422005
X313 1 27 28 12 ped_bjt_CDNS_129 $T=506400 -362155 0 0 $X=491450 $Y=-377105
X314 1 30 30 28 ped_bjt_CDNS_129 $T=536300 -407055 0 0 $X=521350 $Y=-422005
X315 1 28 28 12 ped_bjt_CDNS_129 $T=536300 -362155 0 0 $X=521350 $Y=-377105
X316 1 20 30 29 ped_bjt_CDNS_129 $T=566200 -407055 0 0 $X=551250 $Y=-422005
X317 1 29 28 12 ped_bjt_CDNS_129 $T=566200 -362155 0 0 $X=551250 $Y=-377105
X318 1 24 19 nedia_bjt_CDNS_130 $T=605825 -453070 0 0 $X=589605 $Y=-472460
X319 1 19 9 nedia_bjt_CDNS_130 $T=638265 -453070 0 0 $X=622045 $Y=-472460
X320 1 25 24 CurrentMirror_x10_LV $T=462060 -583750 0 0 $X=464980 $Y=-581340
X321 1 31 33 13 CurrretMirrorx10_HV $T=233030 -895410 0 0 $X=233030 $Y=-895405
X322 26 32 1 rpp1k1_CDNS_173 $T=491630 -471915 1 270 $X=482630 $Y=-499135
X323 1 26 1 rpp1k1_CDNS_173 $T=482850 -454365 1 90 $X=482630 $Y=-457525
X324 1 9 rpp1k1_CDNS_174 $T=586330 -479410 0 270 $X=586110 $Y=-491630
X325 21 1 HVMOS_GateRingM1 $T=665550 -549195 0 0 $X=665550 $Y=-549195
X326 22 1 HVMOS_GateRingM1 $T=665550 -414415 0 0 $X=665550 $Y=-414415
X327 2 1 8 3 34 AND2HDX0 $T=292485 -577600 1 0 $X=292055 $Y=-582720
X328 2 1 8 4 35 AND2HDX0 $T=292485 -577600 0 0 $X=292055 $Y=-578000
X329 2 1 8 5 36 AND2HDX0 $T=292485 -568640 1 0 $X=292055 $Y=-573760
X330 2 1 8 6 37 AND2HDX0 $T=292485 -568640 0 0 $X=292055 $Y=-569040
X331 2 1 8 7 38 AND2HDX0 $T=292485 -559680 1 0 $X=292055 $Y=-564800
X332 9 1 39 14 IN_3VX2 $T=306065 -577600 1 0 $X=305635 $Y=-582720
X333 9 1 40 15 IN_3VX2 $T=306065 -577600 0 0 $X=305635 $Y=-578240
X334 9 1 41 16 IN_3VX2 $T=306065 -568640 1 0 $X=305635 $Y=-573760
X335 9 1 42 17 IN_3VX2 $T=306065 -568640 0 0 $X=305635 $Y=-569280
X336 9 1 43 18 IN_3VX2 $T=306065 -559680 1 0 $X=305635 $Y=-564800
X337 9 1 10 34 39 LSHVT18U3VX1 $T=299905 -577600 1 0 $X=299475 $Y=-582720
X338 9 1 10 35 40 LSHVT18U3VX1 $T=299905 -577600 0 0 $X=299475 $Y=-578240
X339 9 1 10 36 41 LSHVT18U3VX1 $T=299905 -568640 1 0 $X=299475 $Y=-573760
X340 9 1 10 37 42 LSHVT18U3VX1 $T=299905 -568640 0 0 $X=299475 $Y=-569280
X341 9 1 10 38 43 LSHVT18U3VX1 $T=299905 -559680 1 0 $X=299475 $Y=-564800
D0 1 2 p_dnw AREA=1.14924e-11 PJ=1.36e-05 perimeter=1.36e-05 $X=292055 $Y=-582720 $dt=156
D1 1 2 p_dnw AREA=1.83e-11 PJ=1.732e-05 perimeter=1.732e-05 $X=292055 $Y=-575620 $dt=156
D2 1 2 p_dnw AREA=1.83e-11 PJ=1.732e-05 perimeter=1.732e-05 $X=292055 $Y=-566660 $dt=156
D3 1 9 p_dnw3 AREA=2.78876e-11 PJ=2.52944e-05 perimeter=2.52944e-05 $X=299475 $Y=-582720 $dt=243
D4 1 9 p_dnw3 AREA=4.39223e-11 PJ=2.95088e-05 perimeter=2.95088e-05 $X=299475 $Y=-575620 $dt=243
D5 1 9 p_dnw3 AREA=4.39223e-11 PJ=2.95088e-05 perimeter=2.95088e-05 $X=299475 $Y=-566660 $dt=243
C6 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=590990 $Y=-411685 $dt=317
C7 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=590990 $Y=-398905 $dt=317
C8 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=590990 $Y=-384785 $dt=317
C9 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=590990 $Y=-372005 $dt=317
C10 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=590990 $Y=-357885 $dt=317
C11 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=590990 $Y=-345105 $dt=317
C12 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=597210 $Y=-411685 $dt=317
C13 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=597210 $Y=-398905 $dt=317
C14 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=597210 $Y=-384785 $dt=317
C15 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=597210 $Y=-372005 $dt=317
C16 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=597210 $Y=-357885 $dt=317
C17 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=597210 $Y=-345105 $dt=317
C18 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=603430 $Y=-411685 $dt=317
C19 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=603430 $Y=-398905 $dt=317
C20 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=603430 $Y=-384785 $dt=317
C21 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=603430 $Y=-372005 $dt=317
C22 12 19 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=603430 $Y=-357885 $dt=317
C23 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=603430 $Y=-345105 $dt=317
C24 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=609650 $Y=-411685 $dt=317
C25 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=609650 $Y=-398905 $dt=317
C26 12 19 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=609650 $Y=-384785 $dt=317
C27 12 19 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=609650 $Y=-372005 $dt=317
C28 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=609650 $Y=-357885 $dt=317
C29 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=609650 $Y=-345105 $dt=317
C30 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=615870 $Y=-411685 $dt=317
C31 12 19 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=615870 $Y=-398905 $dt=317
C32 12 19 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=615870 $Y=-384785 $dt=317
C33 12 19 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=615870 $Y=-372005 $dt=317
C34 12 19 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=615870 $Y=-357885 $dt=317
C35 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=615870 $Y=-345105 $dt=317
C36 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=622090 $Y=-411685 $dt=317
C37 12 19 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=622090 $Y=-398905 $dt=317
C38 12 19 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=622090 $Y=-384785 $dt=317
C39 12 19 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=622090 $Y=-372005 $dt=317
C40 12 19 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=622090 $Y=-357885 $dt=317
C41 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=622090 $Y=-345105 $dt=317
C42 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=628310 $Y=-411685 $dt=317
C43 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=628310 $Y=-398905 $dt=317
C44 12 19 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=628310 $Y=-384785 $dt=317
C45 12 19 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=628310 $Y=-372005 $dt=317
C46 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=628310 $Y=-357885 $dt=317
C47 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=628310 $Y=-345105 $dt=317
C48 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=634530 $Y=-411685 $dt=317
C49 12 19 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=634530 $Y=-398905 $dt=317
C50 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=634530 $Y=-384785 $dt=317
C51 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=634530 $Y=-372005 $dt=317
C52 12 19 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=634530 $Y=-357885 $dt=317
C53 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=634530 $Y=-345105 $dt=317
C54 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=640750 $Y=-411685 $dt=317
C55 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=640750 $Y=-398905 $dt=317
C56 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=640750 $Y=-384785 $dt=317
C57 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=640750 $Y=-372005 $dt=317
C58 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=640750 $Y=-357885 $dt=317
C59 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=640750 $Y=-345105 $dt=317
C60 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=646970 $Y=-411685 $dt=317
C61 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=646970 $Y=-398905 $dt=317
C62 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=646970 $Y=-384785 $dt=317
C63 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=646970 $Y=-372005 $dt=317
C64 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=646970 $Y=-357885 $dt=317
C65 19 1 area=6.3936e-11 perimeter=3.372e-05 $[csft5a] $X=646970 $Y=-345105 $dt=317
.ends CurrentSource_All_ST

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_179                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_179 1 2
** N=2 EP=2 FDC=0
.ends VIA3_C_CDNS_179

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_180                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_180 1 2
** N=2 EP=2 FDC=0
.ends VIA2_C_CDNS_180

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIATP_C_CDNS_181                                *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIATP_C_CDNS_181 1 2
** N=2 EP=2 FDC=0
.ends VIATP_C_CDNS_181

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_184                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_184 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_184

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_185                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_185 1 2
** N=2 EP=2 FDC=0
.ends VIA3_C_CDNS_185

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_186                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_186 1 2
** N=2 EP=2 FDC=0
.ends VIA2_C_CDNS_186

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_187                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_187 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_187

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIATP_C_CDNS_192                                *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIATP_C_CDNS_192 1 2
** N=2 EP=2 FDC=0
.ends VIATP_C_CDNS_192

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_193                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_193 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_193

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIATP_C_CDNS_194                                *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIATP_C_CDNS_194 1 2
** N=2 EP=2 FDC=0
.ends VIATP_C_CDNS_194

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_195                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_195 1 2
** N=2 EP=2 FDC=0
.ends VIA3_C_CDNS_195

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_196                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_196 1 2
** N=2 EP=2 FDC=0
.ends VIA2_C_CDNS_196

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIATP_C_CDNS_197                                *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIATP_C_CDNS_197 1 2
** N=2 EP=2 FDC=0
.ends VIATP_C_CDNS_197

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_198                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_198 1 2
** N=2 EP=2 FDC=0
.ends VIA3_C_CDNS_198

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_199                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_199 1 2
** N=2 EP=2 FDC=0
.ends VIA2_C_CDNS_199

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIATP_C_CDNS_200                                *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIATP_C_CDNS_200 1 2
** N=2 EP=2 FDC=0
.ends VIATP_C_CDNS_200

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_201                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_201 1 2
** N=2 EP=2 FDC=0
.ends VIA3_C_CDNS_201

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_202                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_202 1 2
** N=2 EP=2 FDC=0
.ends VIA2_C_CDNS_202

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_204                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_204 1 2
** N=2 EP=2 FDC=0
.ends VIA2_C_CDNS_204

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_208                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_208 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_208

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_209                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_209 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_209

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_210                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_210 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_210

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_212                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_212 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_212

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_214                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_214 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_214

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_215                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_215 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_215

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_216                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_216 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_216

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: rpp1k1_CDNS_217                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt rpp1k1_CDNS_217 1 2 3
** N=3 EP=3 FDC=1
R0 1 2 L=2.3e-05 W=2e-06 $[rpp1k1] $X=0 $Y=0 $dt=244
.ends rpp1k1_CDNS_217

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ResistiveDivider                                *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ResistiveDivider 1 2 3 4
** N=38 EP=4 FDC=36
X0 1 VIA1_C_CDNS_67 $T=5640 29425 0 0 $X=4680 $Y=29175
X1 5 VIA1_C_CDNS_67 $T=8000 27825 0 0 $X=7040 $Y=27575
X2 2 VIA1_C_CDNS_67 $T=10360 28625 0 0 $X=9400 $Y=28375
X3 1 VIA1_C_CDNS_67 $T=10360 29425 0 0 $X=9400 $Y=29175
X4 5 VIA1_C_CDNS_67 $T=17440 27825 0 0 $X=16480 $Y=27575
X5 1 VIA1_C_CDNS_215 $T=5640 27105 0 0 $X=4680 $Y=26935
X6 1 VIA1_C_CDNS_215 $T=10360 30945 0 0 $X=9400 $Y=30775
X7 6 VIA1_C_CDNS_215 $T=36320 30945 0 0 $X=35360 $Y=30775
X8 7 VIA1_C_CDNS_215 $T=41040 30945 0 0 $X=40080 $Y=30775
X9 6 VIA1_C_CDNS_216 $T=36320 27170 0 0 $X=35360 $Y=26935
X10 7 VIA1_C_CDNS_216 $T=41040 27170 0 0 $X=40080 $Y=26935
X11 8 8 4 rpp1k1_CDNS_217 $T=4280 26555 1 270 $X=2060 $Y=2615
X12 9 9 4 rpp1k1_CDNS_217 $T=4280 31495 0 90 $X=2060 $Y=30555
X13 1 10 4 rpp1k1_CDNS_217 $T=6640 26555 1 270 $X=4420 $Y=2615
X14 3 11 4 rpp1k1_CDNS_217 $T=6640 31495 0 90 $X=4420 $Y=30555
X15 5 10 4 rpp1k1_CDNS_217 $T=9000 26555 1 270 $X=6780 $Y=2615
X16 12 11 4 rpp1k1_CDNS_217 $T=9000 31495 0 90 $X=6780 $Y=30555
X17 2 13 4 rpp1k1_CDNS_217 $T=11360 26555 1 270 $X=9140 $Y=2615
X18 1 14 4 rpp1k1_CDNS_217 $T=11360 31495 0 90 $X=9140 $Y=30555
X19 15 13 4 rpp1k1_CDNS_217 $T=13720 26555 1 270 $X=11500 $Y=2615
X20 16 14 4 rpp1k1_CDNS_217 $T=13720 31495 0 90 $X=11500 $Y=30555
X21 15 17 4 rpp1k1_CDNS_217 $T=16080 26555 1 270 $X=13860 $Y=2615
X22 16 18 4 rpp1k1_CDNS_217 $T=16080 31495 0 90 $X=13860 $Y=30555
X23 5 19 4 rpp1k1_CDNS_217 $T=18440 26555 1 270 $X=16220 $Y=2615
X24 12 20 4 rpp1k1_CDNS_217 $T=18440 31495 0 90 $X=16220 $Y=30555
X25 21 19 4 rpp1k1_CDNS_217 $T=20800 26555 1 270 $X=18580 $Y=2615
X26 22 20 4 rpp1k1_CDNS_217 $T=20800 31495 0 90 $X=18580 $Y=30555
X27 21 23 4 rpp1k1_CDNS_217 $T=23160 26555 1 270 $X=20940 $Y=2615
X28 22 24 4 rpp1k1_CDNS_217 $T=23160 31495 0 90 $X=20940 $Y=30555
X29 25 23 4 rpp1k1_CDNS_217 $T=23520 26555 0 270 $X=23300 $Y=2615
X30 26 24 4 rpp1k1_CDNS_217 $T=23520 31495 1 90 $X=23300 $Y=30555
X31 25 27 4 rpp1k1_CDNS_217 $T=25880 26555 0 270 $X=25660 $Y=2615
X32 26 28 4 rpp1k1_CDNS_217 $T=25880 31495 1 90 $X=25660 $Y=30555
X33 29 27 4 rpp1k1_CDNS_217 $T=28240 26555 0 270 $X=28020 $Y=2615
X34 30 28 4 rpp1k1_CDNS_217 $T=28240 31495 1 90 $X=28020 $Y=30555
X35 31 17 4 rpp1k1_CDNS_217 $T=30600 26555 0 270 $X=30380 $Y=2615
X36 32 18 4 rpp1k1_CDNS_217 $T=30600 31495 1 90 $X=30380 $Y=30555
X37 31 33 4 rpp1k1_CDNS_217 $T=32960 26555 0 270 $X=32740 $Y=2615
X38 32 34 4 rpp1k1_CDNS_217 $T=32960 31495 1 90 $X=32740 $Y=30555
X39 6 33 4 rpp1k1_CDNS_217 $T=35320 26555 0 270 $X=35100 $Y=2615
X40 6 34 4 rpp1k1_CDNS_217 $T=35320 31495 1 90 $X=35100 $Y=30555
X41 29 35 4 rpp1k1_CDNS_217 $T=37680 26555 0 270 $X=37460 $Y=2615
X42 30 36 4 rpp1k1_CDNS_217 $T=37680 31495 1 90 $X=37460 $Y=30555
X43 7 35 4 rpp1k1_CDNS_217 $T=40040 26555 0 270 $X=39820 $Y=2615
X44 7 36 4 rpp1k1_CDNS_217 $T=40040 31495 1 90 $X=39820 $Y=30555
X45 37 37 4 rpp1k1_CDNS_217 $T=42400 26555 0 270 $X=42180 $Y=2615
X46 38 38 4 rpp1k1_CDNS_217 $T=42400 31495 1 90 $X=42180 $Y=30555
.ends ResistiveDivider

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: nedia_bjt_CDNS_218                              *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt nedia_bjt_CDNS_218 1 2 3
** N=3 EP=3 FDC=1
X0 2 3 1 1 LDDN w=1.5e-05 l=1.25e-06 adio=7.02066e-10 pdio=0.00010035 extlay=1 $[nedia_bjt] $X=-680 $Y=-4850 $dt=67
.ends nedia_bjt_CDNS_218

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: LS_HighSide_V3_ST                               *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt LS_HighSide_V3_ST 1 2 3 4 5 6
** N=8 EP=6 FDC=48
X0 4 2 5 1 7 LSHVT18U3VX1 $T=930 23800 0 0 $X=500 $Y=23160
X1 8 VIA1_C_CDNS_184 $T=47650 2015 0 0 $X=47150 $Y=1515
X2 8 VIA1_C_CDNS_208 $T=47650 24870 0 0 $X=47150 $Y=24620
X3 2 VIA1_C_CDNS_209 $T=27465 3795 0 0 $X=26375 $Y=3185
X4 2 VIA1_C_CDNS_209 $T=31045 3795 0 0 $X=29955 $Y=3185
X5 8 VIA1_C_CDNS_210 $T=23305 2015 0 0 $X=22345 $Y=1515
X6 8 VIA1_C_CDNS_210 $T=35205 2015 0 0 $X=34245 $Y=1515
X7 2 VIA1_C_CDNS_212 $T=27595 48515 0 0 $X=26845 $Y=48025
X8 2 VIA1_C_CDNS_212 $T=31045 48515 0 0 $X=30295 $Y=48025
X9 7 VIA2_C_CDNS_214 $T=29255 16375 0 0 $X=28905 $Y=15875
X10 7 VIA2_C_CDNS_214 $T=29255 35410 0 0 $X=28905 $Y=34910
X11 6 8 3 2 ResistiveDivider $T=47840 -3755 0 0 $X=49560 $Y=-1720
X12 2 8 7 nedia_bjt_CDNS_218 $T=29255 22435 0 0 $X=13035 $Y=3045
D0 2 4 p_dnw3 AREA=2.0854e-11 PJ=2.08144e-05 perimeter=2.08144e-05 $X=500 $Y=25780 $dt=243
.ends LS_HighSide_V3_ST

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA1_C_CDNS_205                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA1_C_CDNS_205 1
** N=1 EP=1 FDC=0
.ends VIA1_C_CDNS_205

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_206                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_206 1
** N=1 EP=1 FDC=0
.ends VIA2_C_CDNS_206

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ped_bjt_CDNS_219                                *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ped_bjt_CDNS_219 1 2 3 4
** N=4 EP=4 FDC=1
X0 2 4 3 1 LDDP w=2e-05 l=9.4e-07 ad=1.76915e-10 pd=9.48396e-05 adio=5.10846e-10 pdio=8.48181e-05 extlay=1 $[ped_bjt] $X=-2270 $Y=0 $dt=68
.ends ped_bjt_CDNS_219

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: LS_LowSide_V2_ST                                *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt LS_LowSide_V2_ST 1 2 3 4 5 6
** N=8 EP=6 FDC=85
X0 7 VIA2_C_CDNS_65 $T=47050 71945 0 0 $X=46550 $Y=71695
X1 7 VIA2_C_CDNS_65 $T=47050 90160 0 0 $X=46550 $Y=89910
X2 3 VIA2_C_CDNS_66 $T=49045 74680 0 0 $X=48545 $Y=74180
X3 8 VIA1_C_CDNS_205 $T=25620 102035 0 0 $X=24720 $Y=101785
X4 8 VIA1_C_CDNS_205 $T=34020 102035 0 0 $X=33120 $Y=101785
X5 7 VIA2_C_CDNS_206 $T=29820 71945 0 0 $X=28810 $Y=71715
X6 7 VIA2_C_CDNS_206 $T=29820 90140 0 0 $X=28810 $Y=89910
X7 7 VIA1_C_CDNS_208 $T=47050 25520 0 0 $X=46550 $Y=25270
X8 3 VIA1_C_CDNS_208 $T=49045 26320 0 0 $X=48545 $Y=26070
X9 8 VIA1_C_CDNS_208 $T=49045 81000 0 0 $X=48545 $Y=80750
X10 8 VIA1_C_CDNS_208 $T=49045 102035 0 0 $X=48545 $Y=101785
X11 6 2 8 2 ResistiveDivider $T=48405 50775 0 0 $X=50125 $Y=52810
X12 1 2 3 5 4 7 LS_HighSide_V3_ST $T=565 -150 0 0 $X=1065 $Y=-1870
X13 2 8 3 7 ped_bjt_CDNS_219 $T=29820 76060 0 0 $X=14870 $Y=61110
.ends LS_LowSide_V2_ST

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: nedia_bjt_CDNS_220                              *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt nedia_bjt_CDNS_220 1 2 3 4
** N=4 EP=4 FDC=10
X0 2 4 3 1 LDDN w=8e-05 l=1.25e-06 adio=8.7279e-10 pdio=3.7955e-05 extlay=1 $[nedia_bjt] $X=-680 $Y=-4850 $dt=67
X1 2 4 3 1 LDDN w=8e-05 l=1.25e-06 adio=8.7279e-10 pdio=3.7955e-05 extlay=1 $[nedia_bjt] $X=11220 $Y=-4850 $dt=67
X2 2 4 3 1 LDDN w=8e-05 l=1.25e-06 adio=8.7279e-10 pdio=3.7955e-05 extlay=1 $[nedia_bjt] $X=23120 $Y=-4850 $dt=67
X3 2 4 3 1 LDDN w=8e-05 l=1.25e-06 adio=8.7279e-10 pdio=3.7955e-05 extlay=1 $[nedia_bjt] $X=35020 $Y=-4850 $dt=67
X4 2 4 3 1 LDDN w=8e-05 l=1.25e-06 adio=8.7279e-10 pdio=3.7955e-05 extlay=1 $[nedia_bjt] $X=46920 $Y=-4850 $dt=67
X5 2 4 3 1 LDDN w=8e-05 l=1.25e-06 adio=8.7279e-10 pdio=3.7955e-05 extlay=1 $[nedia_bjt] $X=58820 $Y=-4850 $dt=67
X6 2 4 3 1 LDDN w=8e-05 l=1.25e-06 adio=8.7279e-10 pdio=3.7955e-05 extlay=1 $[nedia_bjt] $X=70720 $Y=-4850 $dt=67
X7 2 4 3 1 LDDN w=8e-05 l=1.25e-06 adio=8.7279e-10 pdio=3.7955e-05 extlay=1 $[nedia_bjt] $X=82620 $Y=-4850 $dt=67
X8 2 4 3 1 LDDN w=8e-05 l=1.25e-06 adio=8.7279e-10 pdio=3.7955e-05 extlay=1 $[nedia_bjt] $X=94520 $Y=-4850 $dt=67
X9 2 4 3 1 LDDN w=8e-05 l=1.25e-06 adio=8.7279e-10 pdio=3.7955e-05 extlay=1 $[nedia_bjt] $X=106420 $Y=-4850 $dt=67
.ends nedia_bjt_CDNS_220

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ped_bjt_CDNS_221                                *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ped_bjt_CDNS_221 1 2 3 4
** N=4 EP=4 FDC=13
X0 2 4 3 1 LDDP w=8e-05 l=9.4e-07 ad=2.98618e-10 pd=0.000121287 adio=5.66576e-10 pdio=2.7386e-05 extlay=1 $[ped_bjt] $X=-2270 $Y=0 $dt=68
X1 2 4 3 1 LDDP w=8e-05 l=9.4e-07 ad=2.98618e-10 pd=0.000121287 adio=5.66576e-10 pdio=2.7386e-05 extlay=1 $[ped_bjt] $X=6530 $Y=0 $dt=68
X2 2 4 3 1 LDDP w=8e-05 l=9.4e-07 ad=2.98618e-10 pd=0.000121287 adio=5.66576e-10 pdio=2.7386e-05 extlay=1 $[ped_bjt] $X=15330 $Y=0 $dt=68
X3 2 4 3 1 LDDP w=8e-05 l=9.4e-07 ad=2.98618e-10 pd=0.000121287 adio=5.66576e-10 pdio=2.7386e-05 extlay=1 $[ped_bjt] $X=24130 $Y=0 $dt=68
X4 2 4 3 1 LDDP w=8e-05 l=9.4e-07 ad=2.98618e-10 pd=0.000121287 adio=5.66576e-10 pdio=2.7386e-05 extlay=1 $[ped_bjt] $X=32930 $Y=0 $dt=68
X5 2 4 3 1 LDDP w=8e-05 l=9.4e-07 ad=2.98618e-10 pd=0.000121287 adio=5.66576e-10 pdio=2.7386e-05 extlay=1 $[ped_bjt] $X=41730 $Y=0 $dt=68
X6 2 4 3 1 LDDP w=8e-05 l=9.4e-07 ad=2.98618e-10 pd=0.000121287 adio=5.66576e-10 pdio=2.7386e-05 extlay=1 $[ped_bjt] $X=50530 $Y=0 $dt=68
X7 2 4 3 1 LDDP w=8e-05 l=9.4e-07 ad=2.98618e-10 pd=0.000121287 adio=5.66576e-10 pdio=2.7386e-05 extlay=1 $[ped_bjt] $X=59330 $Y=0 $dt=68
X8 2 4 3 1 LDDP w=8e-05 l=9.4e-07 ad=2.98618e-10 pd=0.000121287 adio=5.66576e-10 pdio=2.7386e-05 extlay=1 $[ped_bjt] $X=68130 $Y=0 $dt=68
X9 2 4 3 1 LDDP w=8e-05 l=9.4e-07 ad=2.98618e-10 pd=0.000121287 adio=5.66576e-10 pdio=2.7386e-05 extlay=1 $[ped_bjt] $X=76930 $Y=0 $dt=68
X10 2 4 3 1 LDDP w=8e-05 l=9.4e-07 ad=2.98618e-10 pd=0.000121287 adio=5.66576e-10 pdio=2.7386e-05 extlay=1 $[ped_bjt] $X=85730 $Y=0 $dt=68
X11 2 4 3 1 LDDP w=8e-05 l=9.4e-07 ad=2.98618e-10 pd=0.000121287 adio=5.66576e-10 pdio=2.7386e-05 extlay=1 $[ped_bjt] $X=94530 $Y=0 $dt=68
X12 2 4 3 1 LDDP w=8e-05 l=9.4e-07 ad=2.98618e-10 pd=0.000121287 adio=5.66576e-10 pdio=2.7386e-05 extlay=1 $[ped_bjt] $X=103330 $Y=0 $dt=68
.ends ped_bjt_CDNS_221

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA2_C_CDNS_178                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA2_C_CDNS_178 1 2
** N=2 EP=2 FDC=0
.ends VIA2_C_CDNS_178

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIATP_C_CDNS_182                                *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIATP_C_CDNS_182 1 2
** N=2 EP=2 FDC=0
.ends VIATP_C_CDNS_182

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VIA3_C_CDNS_183                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VIA3_C_CDNS_183 1 2
** N=2 EP=2 FDC=0
.ends VIA3_C_CDNS_183

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: MASCO__B17                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt MASCO__B17 1 2
** N=2 EP=2 FDC=0
X0 1 2 VIA2_C_CDNS_178 $T=27700 1090 0 0 $X=0 $Y=0
X1 1 2 VIATP_C_CDNS_182 $T=27700 1090 0 0 $X=0 $Y=0
X2 1 2 VIA3_C_CDNS_183 $T=27700 1090 0 0 $X=0 $Y=0
.ends MASCO__B17

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: HalfBridge_ST                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt HalfBridge_ST 1 2 3 4 5 6 7 8
** N=10 EP=8 FDC=156
X0 4 VIA1_C_CDNS_85 $T=14175 52075 0 0 $X=13175 $Y=51075
X1 4 VIA1_C_CDNS_85 $T=14175 161910 0 0 $X=13175 $Y=160910
X2 9 VIA1_C_CDNS_102 $T=129025 103545 0 0 $X=128535 $Y=103055
X3 5 VIA1_C_CDNS_124 $T=129025 34625 0 0 $X=128535 $Y=34395
X4 9 VIA1_C_CDNS_124 $T=129025 46525 0 0 $X=128535 $Y=46295
X5 9 VIA1_C_CDNS_124 $T=129025 58425 0 0 $X=128535 $Y=58195
X6 9 VIA1_C_CDNS_124 $T=129025 70325 0 0 $X=128535 $Y=70095
X7 9 VIA1_C_CDNS_124 $T=129025 82225 0 0 $X=128535 $Y=81995
X8 9 VIA1_C_CDNS_124 $T=129025 94125 0 0 $X=128535 $Y=93895
X9 9 VIA1_C_CDNS_124 $T=129025 106025 0 0 $X=128535 $Y=105795
X10 9 VIA1_C_CDNS_124 $T=129025 117925 0 0 $X=128535 $Y=117695
X11 9 VIA1_C_CDNS_124 $T=129025 129825 0 0 $X=128535 $Y=129595
X12 9 VIA1_C_CDNS_124 $T=129025 141725 0 0 $X=128535 $Y=141495
X13 9 VIA1_C_CDNS_124 $T=129025 153625 0 0 $X=128535 $Y=153395
X14 5 VIA1_C_CDNS_124 $T=197845 34625 0 0 $X=197355 $Y=34395
X15 9 VIA1_C_CDNS_124 $T=197845 46525 0 0 $X=197355 $Y=46295
X16 9 VIA1_C_CDNS_124 $T=197845 58425 0 0 $X=197355 $Y=58195
X17 9 VIA1_C_CDNS_124 $T=197845 70325 0 0 $X=197355 $Y=70095
X18 9 VIA1_C_CDNS_124 $T=197845 82225 0 0 $X=197355 $Y=81995
X19 9 VIA1_C_CDNS_124 $T=197845 94125 0 0 $X=197355 $Y=93895
X20 9 VIA1_C_CDNS_124 $T=197845 106025 0 0 $X=197355 $Y=105795
X21 9 VIA1_C_CDNS_124 $T=197845 117925 0 0 $X=197355 $Y=117695
X22 9 VIA1_C_CDNS_124 $T=197845 129825 0 0 $X=197355 $Y=129595
X23 9 VIA1_C_CDNS_124 $T=197845 141725 0 0 $X=197355 $Y=141495
X24 9 VIA1_C_CDNS_124 $T=197845 153625 0 0 $X=197355 $Y=153395
X25 7 5 M3_MTPcell $T=99900 163655 0 0 $X=99900 $Y=163655
X26 7 5 M3_MTPcell $T=107460 163655 0 0 $X=107460 $Y=163655
X27 7 5 M3_MTPcell $T=115020 163655 0 0 $X=115020 $Y=163655
X28 7 5 M3_MTPcell $T=122580 163655 0 0 $X=122580 $Y=163655
X29 8 5 M3_MTPcell $T=196725 163655 0 0 $X=196725 $Y=163655
X30 8 5 M3_MTPcell $T=204285 163655 0 0 $X=204285 $Y=163655
X31 8 5 M3_MTPcell $T=211845 163655 0 0 $X=211845 $Y=163655
X32 8 5 M3_MTPcell $T=219405 163655 0 0 $X=219405 $Y=163655
X33 6 5 M3_MTPcell $T=282415 163655 0 0 $X=282415 $Y=163655
X34 6 5 M3_MTPcell $T=289975 163655 0 0 $X=289975 $Y=163655
X35 6 5 M3_MTPcell $T=297535 163655 0 0 $X=297535 $Y=163655
X36 6 5 M3_MTPcell $T=305095 163655 0 0 $X=305095 $Y=163655
X37 7 5 VIA3_C_CDNS_179 $T=163455 46525 0 0 $X=140345 $Y=46035
X38 7 5 VIA3_C_CDNS_179 $T=163455 58425 0 0 $X=140345 $Y=57935
X39 7 5 VIA3_C_CDNS_179 $T=163455 70325 0 0 $X=140345 $Y=69835
X40 7 5 VIA3_C_CDNS_179 $T=163455 82225 0 0 $X=140345 $Y=81735
X41 7 5 VIA3_C_CDNS_179 $T=163455 94125 0 0 $X=140345 $Y=93635
X42 7 5 VIA3_C_CDNS_179 $T=163455 106025 0 0 $X=140345 $Y=105535
X43 7 5 VIA3_C_CDNS_179 $T=163455 117925 0 0 $X=140345 $Y=117435
X44 7 5 VIA3_C_CDNS_179 $T=163455 129825 0 0 $X=140345 $Y=129335
X45 7 5 VIA3_C_CDNS_179 $T=163455 141725 0 0 $X=140345 $Y=141235
X46 7 5 VIA3_C_CDNS_179 $T=163455 153625 0 0 $X=140345 $Y=153135
X47 7 5 VIA2_C_CDNS_180 $T=163455 46525 0 0 $X=140345 $Y=46035
X48 7 5 VIA2_C_CDNS_180 $T=163455 58425 0 0 $X=140345 $Y=57935
X49 7 5 VIA2_C_CDNS_180 $T=163455 70325 0 0 $X=140345 $Y=69835
X50 7 5 VIA2_C_CDNS_180 $T=163455 82225 0 0 $X=140345 $Y=81735
X51 7 5 VIA2_C_CDNS_180 $T=163455 94125 0 0 $X=140345 $Y=93635
X52 7 5 VIA2_C_CDNS_180 $T=163455 106025 0 0 $X=140345 $Y=105535
X53 7 5 VIA2_C_CDNS_180 $T=163455 117925 0 0 $X=140345 $Y=117435
X54 7 5 VIA2_C_CDNS_180 $T=163455 129825 0 0 $X=140345 $Y=129335
X55 7 5 VIA2_C_CDNS_180 $T=163455 141725 0 0 $X=140345 $Y=141235
X56 7 5 VIA2_C_CDNS_180 $T=163455 153625 0 0 $X=140345 $Y=153135
X57 7 5 VIATP_C_CDNS_181 $T=163445 46525 0 0 $X=140700 $Y=46145
X58 7 5 VIATP_C_CDNS_181 $T=163445 58425 0 0 $X=140700 $Y=58045
X59 7 5 VIATP_C_CDNS_181 $T=163445 70325 0 0 $X=140700 $Y=69945
X60 7 5 VIATP_C_CDNS_181 $T=163445 82225 0 0 $X=140700 $Y=81845
X61 7 5 VIATP_C_CDNS_181 $T=163445 94125 0 0 $X=140700 $Y=93745
X62 7 5 VIATP_C_CDNS_181 $T=163445 106025 0 0 $X=140700 $Y=105645
X63 7 5 VIATP_C_CDNS_181 $T=163445 117925 0 0 $X=140700 $Y=117545
X64 7 5 VIATP_C_CDNS_181 $T=163445 129825 0 0 $X=140700 $Y=129445
X65 7 5 VIATP_C_CDNS_181 $T=163445 141725 0 0 $X=140700 $Y=141345
X66 7 5 VIATP_C_CDNS_181 $T=163445 153625 0 0 $X=140700 $Y=153245
X67 10 VIA1_C_CDNS_184 $T=253580 161870 0 0 $X=253080 $Y=161370
X68 8 5 VIA3_C_CDNS_185 $T=163435 40575 0 0 $X=135735 $Y=39615
X69 8 5 VIA3_C_CDNS_185 $T=163435 52475 0 0 $X=135735 $Y=51515
X70 8 5 VIA3_C_CDNS_185 $T=163435 64375 0 0 $X=135735 $Y=63415
X71 8 5 VIA3_C_CDNS_185 $T=163435 76275 0 0 $X=135735 $Y=75315
X72 8 5 VIA3_C_CDNS_185 $T=163435 88175 0 0 $X=135735 $Y=87215
X73 8 5 VIA3_C_CDNS_185 $T=163435 100075 0 0 $X=135735 $Y=99115
X74 8 5 VIA3_C_CDNS_185 $T=163435 111975 0 0 $X=135735 $Y=111015
X75 8 5 VIA3_C_CDNS_185 $T=163435 123875 0 0 $X=135735 $Y=122915
X76 8 5 VIA3_C_CDNS_185 $T=163435 135775 0 0 $X=135735 $Y=134815
X77 8 5 VIA3_C_CDNS_185 $T=163435 147675 0 0 $X=135735 $Y=146715
X78 8 5 VIA3_C_CDNS_185 $T=163435 159575 0 0 $X=135735 $Y=158615
X79 8 5 VIA2_C_CDNS_186 $T=163435 40575 0 0 $X=135735 $Y=39615
X80 8 5 VIA2_C_CDNS_186 $T=163435 52475 0 0 $X=135735 $Y=51515
X81 8 5 VIA2_C_CDNS_186 $T=163435 64375 0 0 $X=135735 $Y=63415
X82 8 5 VIA2_C_CDNS_186 $T=163435 76275 0 0 $X=135735 $Y=75315
X83 8 5 VIA2_C_CDNS_186 $T=163435 88175 0 0 $X=135735 $Y=87215
X84 8 5 VIA2_C_CDNS_186 $T=163435 100075 0 0 $X=135735 $Y=99115
X85 8 5 VIA2_C_CDNS_186 $T=163435 111975 0 0 $X=135735 $Y=111015
X86 8 5 VIA2_C_CDNS_186 $T=163435 123875 0 0 $X=135735 $Y=122915
X87 8 5 VIA2_C_CDNS_186 $T=163435 135775 0 0 $X=135735 $Y=134815
X88 8 5 VIA2_C_CDNS_186 $T=163435 147675 0 0 $X=135735 $Y=146715
X89 8 5 VIA2_C_CDNS_186 $T=163435 159575 0 0 $X=135735 $Y=158615
X90 3 VIA1_C_CDNS_187 $T=1755 49785 0 0 $X=755 $Y=49335
X91 3 VIA1_C_CDNS_187 $T=1755 159620 0 0 $X=755 $Y=159170
X92 8 5 VIATP_C_CDNS_192 $T=163435 40575 0 0 $X=135735 $Y=39615
X93 8 5 VIATP_C_CDNS_192 $T=163435 52475 0 0 $X=135735 $Y=51515
X94 8 5 VIATP_C_CDNS_192 $T=163435 64375 0 0 $X=135735 $Y=63415
X95 8 5 VIATP_C_CDNS_192 $T=163435 76275 0 0 $X=135735 $Y=75315
X96 8 5 VIATP_C_CDNS_192 $T=163435 88175 0 0 $X=135735 $Y=87215
X97 8 5 VIATP_C_CDNS_192 $T=163435 100075 0 0 $X=135735 $Y=99115
X98 8 5 VIATP_C_CDNS_192 $T=163435 111975 0 0 $X=135735 $Y=111015
X99 8 5 VIATP_C_CDNS_192 $T=163435 123875 0 0 $X=135735 $Y=122915
X100 8 5 VIATP_C_CDNS_192 $T=163435 135775 0 0 $X=135735 $Y=134815
X101 8 5 VIATP_C_CDNS_192 $T=163435 147675 0 0 $X=135735 $Y=146715
X102 8 5 VIATP_C_CDNS_192 $T=163435 159575 0 0 $X=135735 $Y=158615
X103 10 VIA1_C_CDNS_193 $T=225325 47275 0 0 $X=224825 $Y=46025
X104 10 VIA1_C_CDNS_193 $T=225325 56075 0 0 $X=224825 $Y=54825
X105 10 VIA1_C_CDNS_193 $T=225325 64875 0 0 $X=224825 $Y=63625
X106 10 VIA1_C_CDNS_193 $T=225325 73675 0 0 $X=224825 $Y=72425
X107 10 VIA1_C_CDNS_193 $T=225325 82475 0 0 $X=224825 $Y=81225
X108 10 VIA1_C_CDNS_193 $T=225325 91275 0 0 $X=224825 $Y=90025
X109 10 VIA1_C_CDNS_193 $T=225325 100075 0 0 $X=224825 $Y=98825
X110 10 VIA1_C_CDNS_193 $T=225325 108875 0 0 $X=224825 $Y=107625
X111 10 VIA1_C_CDNS_193 $T=225325 117675 0 0 $X=224825 $Y=116425
X112 10 VIA1_C_CDNS_193 $T=225325 126475 0 0 $X=224825 $Y=125225
X113 10 VIA1_C_CDNS_193 $T=225325 135275 0 0 $X=224825 $Y=134025
X114 10 VIA1_C_CDNS_193 $T=225325 144075 0 0 $X=224825 $Y=142825
X115 10 VIA1_C_CDNS_193 $T=225325 152875 0 0 $X=224825 $Y=151625
X116 10 VIA1_C_CDNS_193 $T=284305 47275 1 180 $X=283805 $Y=46025
X117 10 VIA1_C_CDNS_193 $T=284305 56075 1 180 $X=283805 $Y=54825
X118 10 VIA1_C_CDNS_193 $T=284305 64875 1 180 $X=283805 $Y=63625
X119 10 VIA1_C_CDNS_193 $T=284305 73675 1 180 $X=283805 $Y=72425
X120 10 VIA1_C_CDNS_193 $T=284305 82475 1 180 $X=283805 $Y=81225
X121 10 VIA1_C_CDNS_193 $T=284305 91275 1 180 $X=283805 $Y=90025
X122 10 VIA1_C_CDNS_193 $T=284305 100075 1 180 $X=283805 $Y=98825
X123 10 VIA1_C_CDNS_193 $T=284305 108875 1 180 $X=283805 $Y=107625
X124 10 VIA1_C_CDNS_193 $T=284305 117675 1 180 $X=283805 $Y=116425
X125 10 VIA1_C_CDNS_193 $T=284305 126475 1 180 $X=283805 $Y=125225
X126 10 VIA1_C_CDNS_193 $T=284305 135275 1 180 $X=283805 $Y=134025
X127 10 VIA1_C_CDNS_193 $T=284305 144075 1 180 $X=283805 $Y=142825
X128 10 VIA1_C_CDNS_193 $T=284305 152875 1 180 $X=283805 $Y=151625
X129 8 5 VIATP_C_CDNS_194 $T=254815 43075 0 0 $X=229720 $Y=42175
X130 8 5 VIATP_C_CDNS_194 $T=254815 157075 0 0 $X=229720 $Y=156175
X131 8 5 VIA3_C_CDNS_195 $T=254815 43075 0 0 $X=229715 $Y=42175
X132 8 5 VIA3_C_CDNS_195 $T=254815 157075 0 0 $X=229715 $Y=156175
X133 8 5 VIA2_C_CDNS_196 $T=254815 43075 0 0 $X=229715 $Y=42175
X134 8 5 VIA2_C_CDNS_196 $T=254815 157075 0 0 $X=229715 $Y=156175
X135 8 5 VIATP_C_CDNS_197 $T=254815 51675 0 0 $X=229715 $Y=50575
X136 8 5 VIATP_C_CDNS_197 $T=254815 60475 0 0 $X=229715 $Y=59375
X137 8 5 VIATP_C_CDNS_197 $T=254815 69275 0 0 $X=229715 $Y=68175
X138 8 5 VIATP_C_CDNS_197 $T=254815 78075 0 0 $X=229715 $Y=76975
X139 8 5 VIATP_C_CDNS_197 $T=254815 86875 0 0 $X=229715 $Y=85775
X140 8 5 VIATP_C_CDNS_197 $T=254815 95675 0 0 $X=229715 $Y=94575
X141 8 5 VIATP_C_CDNS_197 $T=254815 104475 0 0 $X=229715 $Y=103375
X142 8 5 VIATP_C_CDNS_197 $T=254815 113275 0 0 $X=229715 $Y=112175
X143 8 5 VIATP_C_CDNS_197 $T=254815 122075 0 0 $X=229715 $Y=120975
X144 8 5 VIATP_C_CDNS_197 $T=254815 130875 0 0 $X=229715 $Y=129775
X145 8 5 VIATP_C_CDNS_197 $T=254815 139675 0 0 $X=229715 $Y=138575
X146 8 5 VIATP_C_CDNS_197 $T=254815 148475 0 0 $X=229715 $Y=147375
X147 8 5 VIA3_C_CDNS_198 $T=254815 51675 0 0 $X=229715 $Y=50575
X148 8 5 VIA3_C_CDNS_198 $T=254815 60475 0 0 $X=229715 $Y=59375
X149 8 5 VIA3_C_CDNS_198 $T=254815 69275 0 0 $X=229715 $Y=68175
X150 8 5 VIA3_C_CDNS_198 $T=254815 78075 0 0 $X=229715 $Y=76975
X151 8 5 VIA3_C_CDNS_198 $T=254815 86875 0 0 $X=229715 $Y=85775
X152 8 5 VIA3_C_CDNS_198 $T=254815 95675 0 0 $X=229715 $Y=94575
X153 8 5 VIA3_C_CDNS_198 $T=254815 104475 0 0 $X=229715 $Y=103375
X154 8 5 VIA3_C_CDNS_198 $T=254815 113275 0 0 $X=229715 $Y=112175
X155 8 5 VIA3_C_CDNS_198 $T=254815 122075 0 0 $X=229715 $Y=120975
X156 8 5 VIA3_C_CDNS_198 $T=254815 130875 0 0 $X=229715 $Y=129775
X157 8 5 VIA3_C_CDNS_198 $T=254815 139675 0 0 $X=229715 $Y=138575
X158 8 5 VIA3_C_CDNS_198 $T=254815 148475 0 0 $X=229715 $Y=147375
X159 8 5 VIA2_C_CDNS_199 $T=254815 51675 0 0 $X=229715 $Y=50575
X160 8 5 VIA2_C_CDNS_199 $T=254815 60475 0 0 $X=229715 $Y=59375
X161 8 5 VIA2_C_CDNS_199 $T=254815 69275 0 0 $X=229715 $Y=68175
X162 8 5 VIA2_C_CDNS_199 $T=254815 78075 0 0 $X=229715 $Y=76975
X163 8 5 VIA2_C_CDNS_199 $T=254815 86875 0 0 $X=229715 $Y=85775
X164 8 5 VIA2_C_CDNS_199 $T=254815 95675 0 0 $X=229715 $Y=94575
X165 8 5 VIA2_C_CDNS_199 $T=254815 104475 0 0 $X=229715 $Y=103375
X166 8 5 VIA2_C_CDNS_199 $T=254815 113275 0 0 $X=229715 $Y=112175
X167 8 5 VIA2_C_CDNS_199 $T=254815 122075 0 0 $X=229715 $Y=120975
X168 8 5 VIA2_C_CDNS_199 $T=254815 130875 0 0 $X=229715 $Y=129775
X169 8 5 VIA2_C_CDNS_199 $T=254815 139675 0 0 $X=229715 $Y=138575
X170 8 5 VIA2_C_CDNS_199 $T=254815 148475 0 0 $X=229715 $Y=147375
X171 6 5 VIATP_C_CDNS_200 $T=254815 47275 0 0 $X=232935 $Y=45395
X172 6 5 VIATP_C_CDNS_200 $T=254815 56075 0 0 $X=232935 $Y=54195
X173 6 5 VIATP_C_CDNS_200 $T=254815 64875 0 0 $X=232935 $Y=62995
X174 6 5 VIATP_C_CDNS_200 $T=254815 73675 0 0 $X=232935 $Y=71795
X175 6 5 VIATP_C_CDNS_200 $T=254815 82475 0 0 $X=232935 $Y=80595
X176 6 5 VIATP_C_CDNS_200 $T=254815 91275 0 0 $X=232935 $Y=89395
X177 6 5 VIATP_C_CDNS_200 $T=254815 100075 0 0 $X=232935 $Y=98195
X178 6 5 VIATP_C_CDNS_200 $T=254815 108875 0 0 $X=232935 $Y=106995
X179 6 5 VIATP_C_CDNS_200 $T=254815 117675 0 0 $X=232935 $Y=115795
X180 6 5 VIATP_C_CDNS_200 $T=254815 126475 0 0 $X=232935 $Y=124595
X181 6 5 VIATP_C_CDNS_200 $T=254815 135275 0 0 $X=232935 $Y=133395
X182 6 5 VIATP_C_CDNS_200 $T=254815 144075 0 0 $X=232935 $Y=142195
X183 6 5 VIATP_C_CDNS_200 $T=254815 152875 0 0 $X=232935 $Y=150995
X184 6 5 VIA3_C_CDNS_201 $T=254815 47275 0 0 $X=232935 $Y=45395
X185 6 5 VIA3_C_CDNS_201 $T=254815 56075 0 0 $X=232935 $Y=54195
X186 6 5 VIA3_C_CDNS_201 $T=254815 64875 0 0 $X=232935 $Y=62995
X187 6 5 VIA3_C_CDNS_201 $T=254815 73675 0 0 $X=232935 $Y=71795
X188 6 5 VIA3_C_CDNS_201 $T=254815 82475 0 0 $X=232935 $Y=80595
X189 6 5 VIA3_C_CDNS_201 $T=254815 91275 0 0 $X=232935 $Y=89395
X190 6 5 VIA3_C_CDNS_201 $T=254815 100075 0 0 $X=232935 $Y=98195
X191 6 5 VIA3_C_CDNS_201 $T=254815 108875 0 0 $X=232935 $Y=106995
X192 6 5 VIA3_C_CDNS_201 $T=254815 117675 0 0 $X=232935 $Y=115795
X193 6 5 VIA3_C_CDNS_201 $T=254815 126475 0 0 $X=232935 $Y=124595
X194 6 5 VIA3_C_CDNS_201 $T=254815 135275 0 0 $X=232935 $Y=133395
X195 6 5 VIA3_C_CDNS_201 $T=254815 144075 0 0 $X=232935 $Y=142195
X196 6 5 VIA3_C_CDNS_201 $T=254815 152875 0 0 $X=232935 $Y=150995
X197 6 5 VIA2_C_CDNS_202 $T=254815 47275 0 0 $X=232935 $Y=45395
X198 6 5 VIA2_C_CDNS_202 $T=254815 56075 0 0 $X=232935 $Y=54195
X199 6 5 VIA2_C_CDNS_202 $T=254815 64875 0 0 $X=232935 $Y=62995
X200 6 5 VIA2_C_CDNS_202 $T=254815 73675 0 0 $X=232935 $Y=71795
X201 6 5 VIA2_C_CDNS_202 $T=254815 82475 0 0 $X=232935 $Y=80595
X202 6 5 VIA2_C_CDNS_202 $T=254815 91275 0 0 $X=232935 $Y=89395
X203 6 5 VIA2_C_CDNS_202 $T=254815 100075 0 0 $X=232935 $Y=98195
X204 6 5 VIA2_C_CDNS_202 $T=254815 108875 0 0 $X=232935 $Y=106995
X205 6 5 VIA2_C_CDNS_202 $T=254815 117675 0 0 $X=232935 $Y=115795
X206 6 5 VIA2_C_CDNS_202 $T=254815 126475 0 0 $X=232935 $Y=124595
X207 6 5 VIA2_C_CDNS_202 $T=254815 135275 0 0 $X=232935 $Y=133395
X208 6 5 VIA2_C_CDNS_202 $T=254815 144075 0 0 $X=232935 $Y=142195
X209 6 5 VIA2_C_CDNS_202 $T=254815 152875 0 0 $X=232935 $Y=150995
X210 6 5 VIA2_C_CDNS_204 $T=297535 168920 0 0 $X=282745 $Y=168430
X211 6 5 VIA2_C_CDNS_204 $T=297665 170445 0 0 $X=282875 $Y=169955
X212 1 5 6 4 3 10 LS_HighSide_V3_ST $T=2840 133030 0 0 $X=3340 $Y=131310
X213 2 5 6 3 4 9 LS_LowSide_V2_ST $T=2275 23345 0 0 $X=3340 $Y=21475
X214 5 8 7 9 nedia_bjt_CDNS_220 $T=143435 153625 0 270 $X=124045 $Y=30305
X215 5 8 6 10 ped_bjt_CDNS_221 $T=234815 152875 0 270 $X=219865 $Y=32325
X216 7 5 MASCO__B4 $T=99900 148535 0 0 $X=99900 $Y=148535
X217 7 5 MASCO__B4 $T=115020 148535 0 0 $X=115020 $Y=148535
X218 8 5 MASCO__B4 $T=196725 148535 0 0 $X=196725 $Y=148535
X219 8 5 MASCO__B4 $T=211845 148535 0 0 $X=211845 $Y=148535
X220 6 5 MASCO__B4 $T=282415 148535 0 0 $X=282415 $Y=148535
X221 6 5 MASCO__B4 $T=297535 148535 0 0 $X=297535 $Y=148535
X222 7 5 MASCO__B8 $T=99900 27575 0 0 $X=99900 $Y=27575
X223 7 5 MASCO__B8 $T=99900 57815 0 0 $X=99900 $Y=57815
X224 7 5 MASCO__B8 $T=99900 88055 0 0 $X=99900 $Y=88055
X225 7 5 MASCO__B8 $T=99900 118295 0 0 $X=99900 $Y=118295
X226 8 5 MASCO__B8 $T=196725 27575 0 0 $X=196725 $Y=27575
X227 8 5 MASCO__B8 $T=196725 57815 0 0 $X=196725 $Y=57815
X228 8 5 MASCO__B8 $T=196725 88055 0 0 $X=196725 $Y=88055
X229 8 5 MASCO__B8 $T=196725 118295 0 0 $X=196725 $Y=118295
X230 6 5 MASCO__B8 $T=282415 27575 0 0 $X=282415 $Y=27575
X231 6 5 MASCO__B8 $T=282415 57815 0 0 $X=282415 $Y=57815
X232 6 5 MASCO__B8 $T=282415 88055 0 0 $X=282415 $Y=88055
X233 6 5 MASCO__B8 $T=282415 118295 0 0 $X=282415 $Y=118295
X234 7 5 MASCO__B17 $T=135735 43645 0 0 $X=135735 $Y=43645
X235 7 5 MASCO__B17 $T=135735 47225 0 0 $X=135735 $Y=47225
X236 7 5 MASCO__B17 $T=135735 55545 0 0 $X=135735 $Y=55545
X237 7 5 MASCO__B17 $T=135735 59125 0 0 $X=135735 $Y=59125
X238 7 5 MASCO__B17 $T=135735 67445 0 0 $X=135735 $Y=67445
X239 7 5 MASCO__B17 $T=135735 71025 0 0 $X=135735 $Y=71025
X240 7 5 MASCO__B17 $T=135735 79345 0 0 $X=135735 $Y=79345
X241 7 5 MASCO__B17 $T=135735 82925 0 0 $X=135735 $Y=82925
X242 7 5 MASCO__B17 $T=135735 91245 0 0 $X=135735 $Y=91245
X243 7 5 MASCO__B17 $T=135735 94825 0 0 $X=135735 $Y=94825
X244 7 5 MASCO__B17 $T=135735 103145 0 0 $X=135735 $Y=103145
X245 7 5 MASCO__B17 $T=135735 106725 0 0 $X=135735 $Y=106725
X246 7 5 MASCO__B17 $T=135735 115045 0 0 $X=135735 $Y=115045
X247 7 5 MASCO__B17 $T=135735 118625 0 0 $X=135735 $Y=118625
X248 7 5 MASCO__B17 $T=135735 126945 0 0 $X=135735 $Y=126945
X249 7 5 MASCO__B17 $T=135735 130525 0 0 $X=135735 $Y=130525
X250 7 5 MASCO__B17 $T=135735 138845 0 0 $X=135735 $Y=138845
X251 7 5 MASCO__B17 $T=135735 142425 0 0 $X=135735 $Y=142425
X252 7 5 MASCO__B17 $T=135735 150745 0 0 $X=135735 $Y=150745
X253 7 5 MASCO__B17 $T=135735 154325 0 0 $X=135735 $Y=154325
.ends HalfBridge_ST

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: MultiChannel_ST                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt MultiChannel_ST 13 26 27 14 15 28 2 3 16 29
+ 17 30 4 31 18 5 32 6 19 20
+ 33 7 8 34 21 22 9 35 10 23
+ 36 37 24 11 25 12
** N=37 EP=36 FDC=1876
X0 1 2 VIA3_C_CDNS_1 $T=1764740 -903315 0 0 $X=1761910 $Y=-906665
X1 1 2 VIA3_C_CDNS_1 $T=1764785 -910915 0 0 $X=1761955 $Y=-914265
X2 1 2 VIA3_C_CDNS_1 $T=1764815 -926375 0 0 $X=1761985 $Y=-929725
X3 1 2 VIA3_C_CDNS_1 $T=1764885 -918735 0 0 $X=1762055 $Y=-922085
X4 1 2 VIATP_C_CDNS_2 $T=1764605 -903310 0 0 $X=1762095 $Y=-906530
X5 1 2 VIATP_C_CDNS_2 $T=1764810 -926375 0 0 $X=1762300 $Y=-929595
X6 1 2 VIATP_C_CDNS_2 $T=1764845 -918735 0 0 $X=1762335 $Y=-921955
X7 1 2 VIATP_C_CDNS_2 $T=1764875 -910920 0 0 $X=1762365 $Y=-914140
X8 3 2 VIATP_C_CDNS_3 $T=1961560 -744055 0 0 $X=1958340 $Y=-747275
X9 3 2 VIATP_C_CDNS_3 $T=1961560 -736225 0 0 $X=1958340 $Y=-739445
X10 3 2 VIATP_C_CDNS_3 $T=1961560 -728395 0 0 $X=1958340 $Y=-731615
X11 3 2 VIATP_C_CDNS_3 $T=1961560 -720760 0 0 $X=1958340 $Y=-723980
X12 3 2 VIATP_C_CDNS_3 $T=1969200 -744055 0 0 $X=1965980 $Y=-747275
X13 3 2 VIATP_C_CDNS_3 $T=1969200 -736225 0 0 $X=1965980 $Y=-739445
X14 3 2 VIATP_C_CDNS_3 $T=1969200 -728395 0 0 $X=1965980 $Y=-731615
X15 3 2 VIATP_C_CDNS_3 $T=1969200 -720760 0 0 $X=1965980 $Y=-723980
X16 3 2 VIATP_C_CDNS_3 $T=1977020 -744055 0 0 $X=1973800 $Y=-747275
X17 3 2 VIATP_C_CDNS_3 $T=1977020 -736225 0 0 $X=1973800 $Y=-739445
X18 3 2 VIATP_C_CDNS_3 $T=1977020 -728395 0 0 $X=1973800 $Y=-731615
X19 3 2 VIATP_C_CDNS_3 $T=1977020 -720760 0 0 $X=1973800 $Y=-723980
X20 3 2 VIATP_C_CDNS_3 $T=1984840 -744055 0 0 $X=1981620 $Y=-747275
X21 3 2 VIATP_C_CDNS_3 $T=1984840 -736225 0 0 $X=1981620 $Y=-739445
X22 3 2 VIATP_C_CDNS_3 $T=1984840 -728395 0 0 $X=1981620 $Y=-731615
X23 3 2 VIATP_C_CDNS_3 $T=1984840 -720760 0 0 $X=1981620 $Y=-723980
X24 3 2 VIA3_C_CDNS_4 $T=1961560 -744055 0 0 $X=1958340 $Y=-747275
X25 3 2 VIA3_C_CDNS_4 $T=1961560 -736225 0 0 $X=1958340 $Y=-739445
X26 3 2 VIA3_C_CDNS_4 $T=1961560 -728395 0 0 $X=1958340 $Y=-731615
X27 3 2 VIA3_C_CDNS_4 $T=1961560 -720760 0 0 $X=1958340 $Y=-723980
X28 3 2 VIA3_C_CDNS_4 $T=1969200 -744055 0 0 $X=1965980 $Y=-747275
X29 3 2 VIA3_C_CDNS_4 $T=1969200 -736225 0 0 $X=1965980 $Y=-739445
X30 3 2 VIA3_C_CDNS_4 $T=1969200 -728395 0 0 $X=1965980 $Y=-731615
X31 3 2 VIA3_C_CDNS_4 $T=1969200 -720760 0 0 $X=1965980 $Y=-723980
X32 3 2 VIA3_C_CDNS_4 $T=1977020 -744055 0 0 $X=1973800 $Y=-747275
X33 3 2 VIA3_C_CDNS_4 $T=1977020 -736225 0 0 $X=1973800 $Y=-739445
X34 3 2 VIA3_C_CDNS_4 $T=1977020 -728395 0 0 $X=1973800 $Y=-731615
X35 3 2 VIA3_C_CDNS_4 $T=1977020 -720760 0 0 $X=1973800 $Y=-723980
X36 3 2 VIA3_C_CDNS_4 $T=1984840 -744055 0 0 $X=1981620 $Y=-747275
X37 3 2 VIA3_C_CDNS_4 $T=1984840 -736225 0 0 $X=1981620 $Y=-739445
X38 3 2 VIA3_C_CDNS_4 $T=1984840 -728395 0 0 $X=1981620 $Y=-731615
X39 3 2 VIA3_C_CDNS_4 $T=1984840 -720760 0 0 $X=1981620 $Y=-723980
X40 3 2 VIATP_C_CDNS_5 $T=1961560 -755490 0 0 $X=1958340 $Y=-763325
X41 3 2 VIATP_C_CDNS_5 $T=1969200 -755490 0 0 $X=1965980 $Y=-763325
X42 3 2 VIATP_C_CDNS_5 $T=1977020 -755490 0 0 $X=1973800 $Y=-763325
X43 3 2 VIATP_C_CDNS_5 $T=1984840 -755490 0 0 $X=1981620 $Y=-763325
X44 3 2 VIA3_C_CDNS_6 $T=1961560 -755490 0 0 $X=1958340 $Y=-763325
X45 3 2 VIA3_C_CDNS_6 $T=1969200 -755490 0 0 $X=1965980 $Y=-763325
X46 3 2 VIA3_C_CDNS_6 $T=1977020 -755490 0 0 $X=1973800 $Y=-763325
X47 3 2 VIA3_C_CDNS_6 $T=1984840 -755490 0 0 $X=1981620 $Y=-763325
X48 3 2 VIATP_C_CDNS_7 $T=1950565 -744050 0 0 $X=1943440 $Y=-747270
X49 3 2 VIATP_C_CDNS_7 $T=1950565 -736225 0 0 $X=1943440 $Y=-739445
X50 3 2 VIATP_C_CDNS_7 $T=1950565 -728400 0 0 $X=1943440 $Y=-731620
X51 3 2 VIATP_C_CDNS_7 $T=1950565 -720760 0 0 $X=1943440 $Y=-723980
X52 3 2 VIA3_C_CDNS_8 $T=1950565 -744050 0 0 $X=1943440 $Y=-747270
X53 3 2 VIA3_C_CDNS_8 $T=1950565 -736225 0 0 $X=1943440 $Y=-739445
X54 3 2 VIA3_C_CDNS_8 $T=1950565 -728400 0 0 $X=1943440 $Y=-731620
X55 3 2 VIA3_C_CDNS_8 $T=1950565 -720760 0 0 $X=1943440 $Y=-723980
X56 4 2 VIA1_C_CDNS_9 $T=1625830 -1072090 0 0 $X=1623330 $Y=-1077090
X57 4 2 VIA1_C_CDNS_9 $T=1625830 -1060085 0 0 $X=1623330 $Y=-1065085
X58 4 2 VIA1_C_CDNS_10 $T=1563270 -1072090 0 0 $X=1562265 $Y=-1077090
X59 4 2 VIA1_C_CDNS_10 $T=1563270 -1060085 0 0 $X=1562265 $Y=-1065085
X60 4 2 VIA1_C_CDNS_11 $T=1105235 -1072090 0 0 $X=1104235 $Y=-1077090
X61 4 2 VIA1_C_CDNS_11 $T=1105235 -1060085 0 0 $X=1104235 $Y=-1065085
X62 4 2 VIA1_C_CDNS_11 $T=1213235 -1072090 0 0 $X=1212235 $Y=-1077090
X63 4 2 VIA1_C_CDNS_11 $T=1213235 -1060085 0 0 $X=1212235 $Y=-1065085
X64 4 2 VIA1_C_CDNS_11 $T=1453235 -1072090 0 0 $X=1452235 $Y=-1077090
X65 4 2 VIA1_C_CDNS_11 $T=1453235 -1060085 0 0 $X=1452235 $Y=-1065085
X66 4 2 VIA1_C_CDNS_11 $T=1561255 -1072090 0 0 $X=1560255 $Y=-1077090
X67 4 2 VIA1_C_CDNS_11 $T=1561255 -1060085 0 0 $X=1560255 $Y=-1065085
X68 4 VIA1_C_CDNS_12 $T=1559770 -1072090 0 0 $X=1559285 $Y=-1077090
X69 4 VIA1_C_CDNS_12 $T=1559770 -1060085 0 0 $X=1559285 $Y=-1065085
X70 4 2 VIA1_C_CDNS_15 $T=1450840 -1072090 0 0 $X=1449450 $Y=-1077090
X71 4 2 VIA1_C_CDNS_15 $T=1450840 -1060085 0 0 $X=1449450 $Y=-1065085
X72 4 2 VIA1_C_CDNS_17 $T=1278070 -1066090 0 0 $X=1275570 $Y=-1077085
X73 4 2 VIA1_C_CDNS_17 $T=1387905 -1066090 0 0 $X=1385405 $Y=-1077085
X74 4 2 VIA1_C_CDNS_18 $T=1215375 -1072090 0 0 $X=1214235 $Y=-1077090
X75 4 2 VIA1_C_CDNS_18 $T=1215375 -1060085 0 0 $X=1214235 $Y=-1065085
X76 4 VIA1_C_CDNS_19 $T=1211875 -1072090 0 0 $X=1211515 $Y=-1077090
X77 4 VIA1_C_CDNS_19 $T=1211875 -1060085 0 0 $X=1211515 $Y=-1065085
X78 4 VIA1_C_CDNS_22 $T=1106460 -1072090 0 0 $X=1106235 $Y=-1077090
X79 4 VIA1_C_CDNS_22 $T=1106460 -1060085 0 0 $X=1106235 $Y=-1065085
X80 4 2 VIA1_C_CDNS_23 $T=1102960 -1072090 0 0 $X=1101695 $Y=-1077090
X81 4 2 VIA1_C_CDNS_23 $T=1102960 -1060085 0 0 $X=1101695 $Y=-1065085
X82 4 2 VIA1_C_CDNS_26 $T=1639330 -1690185 0 0 $X=1628330 $Y=-1692685
X83 4 2 VIA1_C_CDNS_26 $T=1639330 -1406470 0 0 $X=1628330 $Y=-1408970
X84 4 2 VIA1_C_CDNS_26 $T=1639330 -1342425 0 0 $X=1628330 $Y=-1344925
X85 4 2 VIA1_C_CDNS_27 $T=1633330 -1578610 0 0 $X=1628330 $Y=-1579370
X86 4 2 VIA1_C_CDNS_27 $T=1645330 -1578610 0 0 $X=1640330 $Y=-1579370
X87 4 2 VIA1_C_CDNS_28 $T=1633330 -1581110 0 0 $X=1628330 $Y=-1582850
X88 4 2 VIA1_C_CDNS_28 $T=1645330 -1581110 0 0 $X=1640330 $Y=-1582850
X89 4 2 VIA1_C_CDNS_30 $T=1633330 -1515590 0 0 $X=1628330 $Y=-1517365
X90 4 2 VIA1_C_CDNS_30 $T=1645330 -1515590 0 0 $X=1640330 $Y=-1517365
X91 4 2 VIA1_C_CDNS_32 $T=1633330 -1518090 0 0 $X=1628330 $Y=-1518800
X92 4 2 VIA1_C_CDNS_32 $T=1645330 -1518090 0 0 $X=1640330 $Y=-1518800
X93 4 2 VIA1_C_CDNS_33 $T=1633330 -1230730 0 0 $X=1628330 $Y=-1231370
X94 4 2 VIA1_C_CDNS_33 $T=1645330 -1230730 0 0 $X=1640330 $Y=-1231370
X95 4 2 VIA1_C_CDNS_34 $T=1633330 -1233230 0 0 $X=1628330 $Y=-1235090
X96 4 2 VIA1_C_CDNS_34 $T=1645330 -1233230 0 0 $X=1640330 $Y=-1235090
X97 4 2 VIA1_C_CDNS_36 $T=1633330 -1167710 0 0 $X=1628330 $Y=-1169365
X98 4 2 VIA1_C_CDNS_36 $T=1645330 -1167710 0 0 $X=1640330 $Y=-1169365
X99 4 2 VIA1_C_CDNS_38 $T=1633330 -1170210 0 0 $X=1628330 $Y=-1171040
X100 4 2 VIA1_C_CDNS_38 $T=1645330 -1170210 0 0 $X=1640330 $Y=-1171040
X101 5 2 VIA2_C_CDNS_40 $T=1661330 -1568825 0 0 $X=1656940 $Y=-1580235
X102 5 2 VIA2_C_CDNS_40 $T=1673330 -1568880 0 0 $X=1668940 $Y=-1580290
X103 1 2 M3_MTPcell $T=1783035 -1572545 0 90 $X=1775475 $Y=-1572545
X104 1 2 M3_MTPcell $T=1783035 -1564985 0 90 $X=1775475 $Y=-1564985
X105 1 2 M3_MTPcell $T=1783035 -1557425 0 90 $X=1775475 $Y=-1557425
X106 1 2 M3_MTPcell $T=1783035 -1549865 0 90 $X=1775475 $Y=-1549865
X107 1 2 M3_MTPcell $T=1783035 -1398665 0 90 $X=1775475 $Y=-1398665
X108 1 2 M3_MTPcell $T=1783035 -1391105 0 90 $X=1775475 $Y=-1391105
X109 1 2 M3_MTPcell $T=1783035 -1383545 0 90 $X=1775475 $Y=-1383545
X110 1 2 M3_MTPcell $T=1783035 -1375985 0 90 $X=1775475 $Y=-1375985
X111 1 2 M3_MTPcell $T=1783035 -1224785 0 90 $X=1775475 $Y=-1224785
X112 1 2 M3_MTPcell $T=1783035 -1217225 0 90 $X=1775475 $Y=-1217225
X113 1 2 M3_MTPcell $T=1783035 -1209665 0 90 $X=1775475 $Y=-1209665
X114 1 2 M3_MTPcell $T=1783035 -1202105 0 90 $X=1775475 $Y=-1202105
X115 1 2 M3_MTPcell $T=1790595 -1572545 0 90 $X=1783035 $Y=-1572545
X116 1 2 M3_MTPcell $T=1790595 -1564985 0 90 $X=1783035 $Y=-1564985
X117 1 2 M3_MTPcell $T=1790595 -1557425 0 90 $X=1783035 $Y=-1557425
X118 1 2 M3_MTPcell $T=1790595 -1549865 0 90 $X=1783035 $Y=-1549865
X119 1 2 M3_MTPcell $T=1790595 -1398665 0 90 $X=1783035 $Y=-1398665
X120 1 2 M3_MTPcell $T=1790595 -1391105 0 90 $X=1783035 $Y=-1391105
X121 1 2 M3_MTPcell $T=1790595 -1383545 0 90 $X=1783035 $Y=-1383545
X122 1 2 M3_MTPcell $T=1790595 -1375985 0 90 $X=1783035 $Y=-1375985
X123 1 2 M3_MTPcell $T=1790595 -1224785 0 90 $X=1783035 $Y=-1224785
X124 1 2 M3_MTPcell $T=1790595 -1217225 0 90 $X=1783035 $Y=-1217225
X125 1 2 M3_MTPcell $T=1790595 -1209665 0 90 $X=1783035 $Y=-1209665
X126 1 2 M3_MTPcell $T=1790595 -1202105 0 90 $X=1783035 $Y=-1202105
X127 1 2 M3_MTPcell $T=1798155 -1572545 0 90 $X=1790595 $Y=-1572545
X128 1 2 M3_MTPcell $T=1798155 -1564985 0 90 $X=1790595 $Y=-1564985
X129 1 2 M3_MTPcell $T=1798155 -1557425 0 90 $X=1790595 $Y=-1557425
X130 1 2 M3_MTPcell $T=1798155 -1549865 0 90 $X=1790595 $Y=-1549865
X131 1 2 M3_MTPcell $T=1798155 -1398665 0 90 $X=1790595 $Y=-1398665
X132 1 2 M3_MTPcell $T=1798155 -1391105 0 90 $X=1790595 $Y=-1391105
X133 1 2 M3_MTPcell $T=1798155 -1383545 0 90 $X=1790595 $Y=-1383545
X134 1 2 M3_MTPcell $T=1798155 -1375985 0 90 $X=1790595 $Y=-1375985
X135 1 2 M3_MTPcell $T=1798155 -1224785 0 90 $X=1790595 $Y=-1224785
X136 1 2 M3_MTPcell $T=1798155 -1217225 0 90 $X=1790595 $Y=-1217225
X137 1 2 M3_MTPcell $T=1798155 -1209665 0 90 $X=1790595 $Y=-1209665
X138 1 2 M3_MTPcell $T=1798155 -1202105 0 90 $X=1790595 $Y=-1202105
X139 1 2 M3_MTPcell $T=1805715 -1572545 0 90 $X=1798155 $Y=-1572545
X140 1 2 M3_MTPcell $T=1805715 -1564985 0 90 $X=1798155 $Y=-1564985
X141 1 2 M3_MTPcell $T=1805715 -1557425 0 90 $X=1798155 $Y=-1557425
X142 1 2 M3_MTPcell $T=1805715 -1549865 0 90 $X=1798155 $Y=-1549865
X143 1 2 M3_MTPcell $T=1805715 -1398665 0 90 $X=1798155 $Y=-1398665
X144 1 2 M3_MTPcell $T=1805715 -1391105 0 90 $X=1798155 $Y=-1391105
X145 1 2 M3_MTPcell $T=1805715 -1383545 0 90 $X=1798155 $Y=-1383545
X146 1 2 M3_MTPcell $T=1805715 -1375985 0 90 $X=1798155 $Y=-1375985
X147 1 2 M3_MTPcell $T=1805715 -1224785 0 90 $X=1798155 $Y=-1224785
X148 1 2 M3_MTPcell $T=1805715 -1217225 0 90 $X=1798155 $Y=-1217225
X149 1 2 M3_MTPcell $T=1805715 -1209665 0 90 $X=1798155 $Y=-1209665
X150 1 2 M3_MTPcell $T=1805715 -1202105 0 90 $X=1798155 $Y=-1202105
X151 1 2 M3_MTPcell $T=1798155 -929945 0 0 $X=1798155 $Y=-929945
X152 1 2 M3_MTPcell $T=1798155 -922385 0 0 $X=1798155 $Y=-922385
X153 1 2 M3_MTPcell $T=1798155 -914825 0 0 $X=1798155 $Y=-914825
X154 1 2 M3_MTPcell $T=1798155 -907265 0 0 $X=1798155 $Y=-907265
X155 3 2 M3_MTPcell $T=1965550 -1572545 0 90 $X=1957990 $Y=-1572545
X156 3 2 M3_MTPcell $T=1965550 -1564985 0 90 $X=1957990 $Y=-1564985
X157 3 2 M3_MTPcell $T=1965550 -1557425 0 90 $X=1957990 $Y=-1557425
X158 3 2 M3_MTPcell $T=1965550 -1549865 0 90 $X=1957990 $Y=-1549865
X159 3 2 M3_MTPcell $T=1965550 -1398665 0 90 $X=1957990 $Y=-1398665
X160 3 2 M3_MTPcell $T=1965550 -1391105 0 90 $X=1957990 $Y=-1391105
X161 3 2 M3_MTPcell $T=1965550 -1383545 0 90 $X=1957990 $Y=-1383545
X162 3 2 M3_MTPcell $T=1965550 -1375985 0 90 $X=1957990 $Y=-1375985
X163 3 2 M3_MTPcell $T=1965550 -1224785 0 90 $X=1957990 $Y=-1224785
X164 3 2 M3_MTPcell $T=1965550 -1217225 0 90 $X=1957990 $Y=-1217225
X165 3 2 M3_MTPcell $T=1965550 -1209665 0 90 $X=1957990 $Y=-1209665
X166 3 2 M3_MTPcell $T=1965550 -1202105 0 90 $X=1957990 $Y=-1202105
X167 3 2 M3_MTPcell $T=1973110 -1572545 0 90 $X=1965550 $Y=-1572545
X168 3 2 M3_MTPcell $T=1973110 -1564985 0 90 $X=1965550 $Y=-1564985
X169 3 2 M3_MTPcell $T=1973110 -1557425 0 90 $X=1965550 $Y=-1557425
X170 3 2 M3_MTPcell $T=1973110 -1549865 0 90 $X=1965550 $Y=-1549865
X171 3 2 M3_MTPcell $T=1973110 -1398665 0 90 $X=1965550 $Y=-1398665
X172 3 2 M3_MTPcell $T=1973110 -1391105 0 90 $X=1965550 $Y=-1391105
X173 3 2 M3_MTPcell $T=1973110 -1383545 0 90 $X=1965550 $Y=-1383545
X174 3 2 M3_MTPcell $T=1973110 -1375985 0 90 $X=1965550 $Y=-1375985
X175 3 2 M3_MTPcell $T=1973110 -1224785 0 90 $X=1965550 $Y=-1224785
X176 3 2 M3_MTPcell $T=1973110 -1217225 0 90 $X=1965550 $Y=-1217225
X177 3 2 M3_MTPcell $T=1973110 -1209665 0 90 $X=1965550 $Y=-1209665
X178 3 2 M3_MTPcell $T=1973110 -1202105 0 90 $X=1965550 $Y=-1202105
X179 3 2 M3_MTPcell $T=1980670 -1572545 0 90 $X=1973110 $Y=-1572545
X180 3 2 M3_MTPcell $T=1980670 -1564985 0 90 $X=1973110 $Y=-1564985
X181 3 2 M3_MTPcell $T=1980670 -1557425 0 90 $X=1973110 $Y=-1557425
X182 3 2 M3_MTPcell $T=1980670 -1549865 0 90 $X=1973110 $Y=-1549865
X183 3 2 M3_MTPcell $T=1980670 -1398665 0 90 $X=1973110 $Y=-1398665
X184 3 2 M3_MTPcell $T=1980670 -1391105 0 90 $X=1973110 $Y=-1391105
X185 3 2 M3_MTPcell $T=1980670 -1383545 0 90 $X=1973110 $Y=-1383545
X186 3 2 M3_MTPcell $T=1980670 -1375985 0 90 $X=1973110 $Y=-1375985
X187 3 2 M3_MTPcell $T=1980670 -1224785 0 90 $X=1973110 $Y=-1224785
X188 3 2 M3_MTPcell $T=1980670 -1217225 0 90 $X=1973110 $Y=-1217225
X189 3 2 M3_MTPcell $T=1980670 -1209665 0 90 $X=1973110 $Y=-1209665
X190 3 2 M3_MTPcell $T=1980670 -1202105 0 90 $X=1973110 $Y=-1202105
X191 3 2 M3_MTPcell $T=1988230 -1572545 0 90 $X=1980670 $Y=-1572545
X192 3 2 M3_MTPcell $T=1988230 -1564985 0 90 $X=1980670 $Y=-1564985
X193 3 2 M3_MTPcell $T=1988230 -1557425 0 90 $X=1980670 $Y=-1557425
X194 3 2 M3_MTPcell $T=1988230 -1549865 0 90 $X=1980670 $Y=-1549865
X195 3 2 M3_MTPcell $T=1988230 -1398665 0 90 $X=1980670 $Y=-1398665
X196 3 2 M3_MTPcell $T=1988230 -1391105 0 90 $X=1980670 $Y=-1391105
X197 3 2 M3_MTPcell $T=1988230 -1383545 0 90 $X=1980670 $Y=-1383545
X198 3 2 M3_MTPcell $T=1988230 -1375985 0 90 $X=1980670 $Y=-1375985
X199 3 2 M3_MTPcell $T=1988230 -1224785 0 90 $X=1980670 $Y=-1224785
X200 3 2 M3_MTPcell $T=1988230 -1217225 0 90 $X=1980670 $Y=-1217225
X201 3 2 M3_MTPcell $T=1988230 -1209665 0 90 $X=1980670 $Y=-1209665
X202 3 2 M3_MTPcell $T=1988230 -1202105 0 90 $X=1980670 $Y=-1202105
X203 2 6 7 8 9 10 11 12 4 5
+ 13 3 1 CurrentSource_All_ST $T=719410 -1786300 0 90 $X=1049115 $Y=-1553270
X204 14 15 5 4 2 3 1 16 HalfBridge_ST $T=1267600 -1029845 0 90 $X=1076810 $Y=-1029090
X205 17 18 5 4 2 3 1 19 HalfBridge_ST $T=1441480 -1029845 0 90 $X=1250690 $Y=-1029090
X206 20 21 5 4 2 3 1 22 HalfBridge_ST $T=1615360 -1029845 0 90 $X=1424570 $Y=-1029090
X207 23 24 5 4 2 3 1 25 HalfBridge_ST $T=1789240 -1029845 0 90 $X=1598450 $Y=-1029090
X208 26 27 5 4 2 3 1 28 HalfBridge_ST $T=1675575 -1743760 0 0 $X=1676330 $Y=-1726215
X209 29 30 5 4 2 3 1 31 HalfBridge_ST $T=1675575 -1569880 0 0 $X=1676330 $Y=-1552335
X210 32 33 5 4 2 3 1 34 HalfBridge_ST $T=1675575 -1396000 0 0 $X=1676330 $Y=-1378455
X211 35 36 5 4 2 3 1 37 HalfBridge_ST $T=1675575 -1222120 0 0 $X=1676330 $Y=-1204575
X212 3 2 MASCO__B4 $T=1081265 -747430 0 0 $X=1081265 $Y=-747430
X213 3 2 MASCO__B4 $T=1081265 -732310 0 0 $X=1081265 $Y=-732310
X214 3 2 MASCO__B4 $T=1957990 -778745 0 0 $X=1957990 $Y=-778745
X215 3 2 MASCO__B4 $T=1973110 -778745 0 0 $X=1973110 $Y=-778745
X216 3 2 MASCO__B8 $T=1020785 -747430 0 0 $X=1020785 $Y=-747430
X217 3 2 MASCO__B8 $T=1051025 -747430 0 0 $X=1051025 $Y=-747430
X218 1 2 MASCO__B8 $T=1240025 -929945 0 0 $X=1240025 $Y=-929945
X219 3 2 MASCO__B8 $T=1240025 -747430 0 0 $X=1240025 $Y=-747430
X220 1 2 MASCO__B8 $T=1413905 -929945 0 0 $X=1413905 $Y=-929945
X221 3 2 MASCO__B8 $T=1413905 -747430 0 0 $X=1413905 $Y=-747430
X222 1 2 MASCO__B8 $T=1587785 -929945 0 0 $X=1587785 $Y=-929945
X223 3 2 MASCO__B8 $T=1587785 -747430 0 0 $X=1587785 $Y=-747430
X224 3 2 MASCO__B8 $T=1761665 -747430 0 0 $X=1761665 $Y=-747430
X225 1 2 MASCO__B8 $T=1767915 -929945 0 0 $X=1767915 $Y=-929945
X226 1 2 MASCO__B8 $T=1775475 -1050905 0 0 $X=1775475 $Y=-1050905
X227 1 2 MASCO__B8 $T=1775475 -1020665 0 0 $X=1775475 $Y=-1020665
X228 1 2 MASCO__B8 $T=1775475 -990425 0 0 $X=1775475 $Y=-990425
X229 1 2 MASCO__B8 $T=1775475 -960185 0 0 $X=1775475 $Y=-960185
X230 3 2 MASCO__B8 $T=1791905 -747430 0 0 $X=1791905 $Y=-747430
X231 3 2 MASCO__B8 $T=1822145 -747430 0 0 $X=1822145 $Y=-747430
X232 3 2 MASCO__B8 $T=1852385 -747430 0 0 $X=1852385 $Y=-747430
X233 3 2 MASCO__B8 $T=1882625 -747430 0 0 $X=1882625 $Y=-747430
X234 3 2 MASCO__B8 $T=1912865 -747430 0 0 $X=1912865 $Y=-747430
X235 3 2 MASCO__B8 $T=1957990 -1050905 0 0 $X=1957990 $Y=-1050905
X236 3 2 MASCO__B8 $T=1957990 -1020665 0 0 $X=1957990 $Y=-1020665
X237 3 2 MASCO__B8 $T=1957990 -990425 0 0 $X=1957990 $Y=-990425
X238 3 2 MASCO__B8 $T=1957990 -960185 0 0 $X=1957990 $Y=-960185
X239 3 2 MASCO__B8 $T=1957990 -929945 0 0 $X=1957990 $Y=-929945
X240 3 2 MASCO__B8 $T=1957990 -899705 0 0 $X=1957990 $Y=-899705
X241 3 2 MASCO__B8 $T=1957990 -869465 0 0 $X=1957990 $Y=-869465
X242 3 2 MASCO__B8 $T=1957990 -839225 0 0 $X=1957990 $Y=-839225
X243 3 2 MASCO__B8 $T=1957990 -808985 0 0 $X=1957990 $Y=-808985
.ends MultiChannel_ST
